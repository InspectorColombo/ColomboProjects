# Repository InspectorColombo/ColomboProjects (continued)

## EAGLE design SoftStartBoard/schematic/SoftStart_V1_0_TO_PRINT.brd

Board: 2 copper layers, 130.0 x 130.0 mm, 304 parts (236 on the bottom side), 164 nets.

Parts:
C1, C8, C19, C26, C37, C44, C55, C62: 47uFx16V; CE_6.3MM
C2, C20, C38, C56: 470uFx25V; CE_10MM
C3, C21, C39, C57: 1000uFx25V; CE_10MM
C4, C22, C40, C58: 0.1uFx25V; RSMD_1206
C5, C23, C41, C59: 0.1uFx25V; RSMD_0805
C6, C24, C42, C60: 1nF x 16V; RSMD_0805
C7, C9, C17, C18, C25, C27, C35, C36, C43, C45, C53, C54, C61, C63, C71, C72: 0.1uF x 16V; RSMD_0805
C10, C28, C46, C64: 220pFx25V; RSMD_0805
C11, C13, C16, C29, C31, C34, C47, C49, C52, C65, C67, C70: 1.0uFx25V; RSMD_1206
C12, C14, C15, C30, C32, C33, C48, C50, C51, C66, C68, C69: 47uFx25V; CE_6.3MM
D1, D2, D3, D4, D6, D7, D9, D10, D11, D13, D14, D15: B120; DO-214AC
D5, D8, D12, D16: LL4148; SOD-80
F1, F2, F3, F4: 20A; FUSE_AUTO_MINI_ON_TERMINALS
L1, L4, L7, L10: 680uHx0.17A; LCHB0608
L2, L5, L8, L11: 680uH x 0.07A; LCHB0608
L3, L6, L9, L12: 1.0mH x 0.05A; LCHB0608
R1, R10, R19, R55, R63, R86, R94, R117: 4K7; RSMD_0805
R2, R20, R64, R95: 47K; RSMD_0805
R3, R21, R65, R96: 10R*; RSMD_1206_BIG_GAP
R4, R35, R66, R97: 9K1; RSMD_0805
R5, R36, R67, R98: 1K3; RSMD_0805
R6, R7, R32, R37, R38, R58, R68, R69, R89, R99, R100, R120: 20R; RSMD_0805
R8, R16, R17, R33, R39, R46, R59, R61, R70, R77, R90, R92, R101, R108, R121, R123: 10K; RSMD_0805
R9, R13, R14, R15, R40, R43, R44, R45, R71, R74, R75, R76, R102, R105, R106, R107: 51K; RSMD_0805
R11, R41, R72, R103: 36K; RSMD_0805
R12, R42, R73, R104: 100K; RSMD_0805
R18, R62, R93, R124: 20R*; RSMD_1206
R22, R25, R34, R47, R50, R60, R78, R81, R91, R109, R112, R122: 5K1; RSMD_0805
R23, R48, R79, R110: 10K; RSMD_1206_BIG_GAP
R24, R49, R80, R111: 1M0; RSMD_0805
R26, R51, R82, R113: 2K0; RSMD_0805
R27, R52, R83, R114: 2R0; RSMD_1206_BIG_GAP
R28, R53, R84, R115: 15K; RSMD_0805
R29, R54, R85, R116: 1K6; RSMD_0805
R30, R56, R87, R118: 20K; RSMD_0805
R31, R57, R88, R119: 510K*; RSMD_0805
T1, T2, T3, T4, T5, T9, T10, T11, T15, T16, T17, T18, T22, T23, T24, T25: PK616BA; PDFN_5X6P
T6, T12, T19, T26: BC857; SOT23
T7, T13, T20, T27: BC847; SOT23
T8, T14, T21, T28: 2N7002; SOT23
U1, U4, U7, U10: TP2274; SOIC14
U2, U5, U8, U11: AMS1117; SOT223(WAVE_SOLDERING)
U3, U6, U9, U12: MC34063; SOIC8
X1, X6, X13, X19: +12V; RPI_6.3
X2, X7, X14, X20: GND; RPI_6.3
X3, X4, X8, X9, X15, X16, X21, X22: LAMP; RPI_6.3
X5, X11, X17, X23: SET_DUTY_CYCLE(10K); PIN3X1_2.54MM_WITH_CLAMP
X10, X12, X18, X24: ON/OFF; PIN2X1_2.54_WITH_CLAMP
ZD1, ZD2, ZD3, ZD4, ZD5, ZD6, ZD7, ZD8, ZD9, ZD10, ZD11, ZD12: 5V6; SOD-80

Connections:
+10V: C1.PLUS, C5.PAD_1, C7.PAD_1, R5.PAD_0, R9.PAD_1, R14.PAD_1, R18.PAD_0, R31.PAD_1, R33.PAD_1, U1.4, U2.2, U2.4, X5.1
+10V1: C19.PLUS, C23.PAD_1, C25.PAD_1, R36.PAD_0, R40.PAD_1, R44.PAD_1, R57.PAD_1, R59.PAD_1, R62.PAD_0, U4.4, U5.2, U5.4, X11.1
+10V2: C37.PLUS, C41.PAD_1, C43.PAD_1, R67.PAD_0, R71.PAD_1, R75.PAD_1, R88.PAD_1, R90.PAD_1, R93.PAD_0, U7.4, U8.2, U8.4, X17.1
+10V3: C55.PLUS, C59.PAD_1, C61.PAD_1, R98.PAD_0, R102.PAD_1, R106.PAD_1, R119.PAD_1, R121.PAD_1, R124.PAD_0, U10.4, U11.2, U11.4, X23.1
+12V: C3.PLUS, D1.ANODE, D3.CATHODE, F1.PAD0, X3.PAD1, X3.PAD2
+12V1: C21.PLUS, D4.CATHODE, D6.ANODE, F2.PAD0, X8.PAD1, X8.PAD2
+12V2: C39.PLUS, D9.CATHODE, D10.ANODE, F3.PAD0, X15.PAD1, X15.PAD2
+12V3: C57.PLUS, D13.CATHODE, D14.ANODE, F4.PAD0, X21.PAD1, X21.PAD2
+13V_RAW: C15.PLUS, C16.PAD_0, L3.2, U2.3
+13V_RAW1: C33.PLUS, C34.PAD_0, L6.2, U5.3
+13V_RAW2: C51.PLUS, C52.PAD_0, L9.2, U8.3
+13V_RAW3: C69.PLUS, C70.PAD_0, L12.2, U11.3
GND: C1.MINUS, C2.MINUS, C3.MINUS, C4.PAD_0, C5.PAD_0, C7.PAD_0, C8.MINUS, C9.PAD_0, C10.PAD_0, C13.PAD_1, C14.MINUS, C15.MINUS, C16.PAD_1, C17.PAD_0, C18.PAD_0, L2.2, R2.PAD_0, R4.PAD_0, R8.PAD_1, R10.PAD_0, R11.PAD_0, R15.PAD_1, R29.PAD_0, T1.S1, T1.S2, T1.S3, T2.S1, T2.S2, T2.S3, T3.S1, T3.S2, T3.S3, T4.S1, T4.S2, T4.S3, T6.3, T8.2, U1.11, U3.2, U3.4, X5.3, X10.1, ZD2.ANODE, ZD3.ANODE
GND1: C19.MINUS, C20.MINUS, C21.MINUS, C22.PAD_0, C23.PAD_0, C25.PAD_0, C26.MINUS, C27.PAD_0, C28.PAD_0, C31.PAD_1, C32.MINUS, C33.MINUS, C34.PAD_1, C35.PAD_0, C36.PAD_0, L5.2, R20.PAD_0, R35.PAD_0, R39.PAD_1, R41.PAD_0, R45.PAD_1, R54.PAD_0, R55.PAD_0, T5.S1, T5.S2, T5.S3, T9.S1, T9.S2, T9.S3, T10.S1, T10.S2, T10.S3, T11.S1, T11.S2, T11.S3, T12.3, T14.2, U4.11, U6.2, U6.4, X11.3, X12.1, ZD5.ANODE, ZD6.ANODE
GND2: C37.MINUS, C38.MINUS, C39.MINUS, C40.PAD_0, C41.PAD_0, C43.PAD_0, C44.MINUS, C45.PAD_0, C46.PAD_0, C49.PAD_1, C50.MINUS, C51.MINUS, C52.PAD_1, C53.PAD_0, C54.PAD_0, L8.2, R64.PAD_0, R66.PAD_0, R70.PAD_1, R72.PAD_0, R76.PAD_1, R85.PAD_0, R86.PAD_0, T15.S1, T15.S2, T15.S3, T16.S1, T16.S2, T16.S3, T17.S1, T17.S2, T17.S3, T18.S1, T18.S2, T18.S3, T19.3, T21.2, U7.11, U9.2, U9.4, X17.3, X18.1, ZD8.ANODE, ZD9.ANODE
GND3: C55.MINUS, C56.MINUS, C57.MINUS, C58.PAD_0, C59.PAD_0, C61.PAD_0, C62.MINUS, C63.PAD_0, C64.PAD_0, C67.PAD_1, C68.MINUS, C69.MINUS, C70.PAD_1, C71.PAD_0, C72.PAD_0, L11.2, R95.PAD_0, R97.PAD_0, R101.PAD_1, R103.PAD_0, R107.PAD_1, R116.PAD_0, R117.PAD_0, T22.S1, T22.S2, T22.S3, T23.S1, T23.S2, T23.S3, T24.S1, T24.S2, T24.S3, T25.S1, T25.S2, T25.S3, T26.3, T28.2, U10.11, U12.2, U12.4, X23.3, X24.1, ZD11.ANODE, ZD12.ANODE
unnamed: R1.PAD_0, R2.PAD_1, T1.G, T2.G, ZD1.CATHODE
unnamed: T1.D, T1.D1, T1.D2, T1.D3, T1.D4, T2.D, T2.D1, T2.D2, T2.D3, T2.D4, X2.PAD1, X2.PAD2
unnamed: ZD1.ANODE, ZD2.CATHODE
unnamed: F1.PAD1, R1.PAD_1, X1.PAD1, X1.PAD2
unnamed: L1.1, R26.PAD_1, R27.PAD_0, U3.7
unnamed: D1.CATHODE, R3.PAD_1
unnamed: R4.PAD_1, R5.PAD_1, U2.1
unnamed: D3.ANODE, T3.D, T3.D1, T3.D2, T3.D3, T3.D4, T4.D, T4.D1, T4.D2, T4.D3, T4.D4, X4.PAD1, X4.PAD2
unnamed: R7.PAD_0, T3.G
unnamed: R6.PAD_0, T4.G
unnamed: D5.CATHODE, R34.PAD_0
unnamed: R12.PAD_0, R13.PAD_0, U1.5
unnamed: R12.PAD_1, R16.PAD_0, U1.7
unnamed: R9.PAD_0, R11.PAD_1, U1.6
unnamed: R10.PAD_1, R30.PAD_1, U1.2
unnamed: R14.PAD_0, R15.PAD_0, U1.10
unnamed: C6.PAD_1, R16.PAD_1, U1.9
unnamed: C6.PAD_0, R13.PAD_1, U1.8, U1.13
unnamed: D5.ANODE, R30.PAD_0, U1.1
unnamed: C9.PAD_1, R22.PAD_1, R23.PAD_0, R34.PAD_1
unnamed: C17.PAD_1, R17.PAD_0, T8.1, ZD3.CATHODE
unnamed: R22.PAD_0, X5.2
unnamed: R23.PAD_1, R24.PAD_0, U1.12
unnamed: R24.PAD_1, R25.PAD_0, U1.14
unnamed: R25.PAD_1, T6.1, T7.1
unnamed: R6.PAD_1, R7.PAD_1, R8.PAD_0, T6.2, T7.2
unnamed: C18.PAD_1, R18.PAD_1, T7.3
unnamed: C11.PAD_1, C12.PLUS, L1.2, U3.1
unnamed: C11.PAD_0, C12.MINUS, D2.ANODE, L2.1
unnamed: C2.PLUS, C4.PAD_1, R3.PAD_0, R27.PAD_1, U3.6
unnamed: R26.PAD_0, U3.8
unnamed: C10.PAD_1, U3.3
unnamed: C13.PAD_0, C14.PLUS, D2.CATHODE, L3.1, R28.PAD_1
unnamed: R28.PAD_0, R29.PAD_1, U3.5
unnamed: R32.PAD_0, T8.3
unnamed: C8.PLUS, R31.PAD_0, R32.PAD_1, U1.3
unnamed: R17.PAD_1, R33.PAD_0, X10.2
unnamed: R19.PAD_0, R20.PAD_1, T5.G, T9.G, ZD4.CATHODE
unnamed: T5.D, T5.D1, T5.D2, T5.D3, T5.D4, T9.D, T9.D1, T9.D2, T9.D3, T9.D4, X7.PAD1, X7.PAD2
unnamed: ZD4.ANODE, ZD5.CATHODE
unnamed: F2.PAD1, R19.PAD_1, X6.PAD1, X6.PAD2
unnamed: D6.CATHODE, R21.PAD_1
unnamed: R35.PAD_1, R36.PAD_1, U5.1
unnamed: D4.ANODE, T10.D, T10.D1, T10.D2, T10.D3, T10.D4, T11.D, T11.D1, T11.D2, T11.D3, T11.D4, X9.PAD1, X9.PAD2
unnamed: R38.PAD_0, T10.G
unnamed: R37.PAD_0, T11.G
unnamed: R42.PAD_0, R43.PAD_0, U4.5
unnamed: R42.PAD_1, R46.PAD_0, U4.7
unnamed: R40.PAD_0, R41.PAD_1, U4.6
unnamed: R44.PAD_0, R45.PAD_0, U4.10
unnamed: C24.PAD_1, R46.PAD_1, U4.9
unnamed: C24.PAD_0, R43.PAD_1, U4.8, U4.13
unnamed: C27.PAD_1, R47.PAD_1, R48.PAD_0, R60.PAD_1
unnamed: R47.PAD_0, X11.2
unnamed: R48.PAD_1, R49.PAD_0, U4.12
unnamed: R49.PAD_1, R50.PAD_0, U4.14
unnamed: R50.PAD_1, T12.1, T13.1
unnamed: R37.PAD_1, R38.PAD_1, R39.PAD_0, T12.2, T13.2
unnamed: L4.1, R51.PAD_1, R52.PAD_0, U6.7
unnamed: C29.PAD_1, C30.PLUS, L4.2, U6.1
unnamed: C20.PLUS, C22.PAD_1, R21.PAD_0, R52.PAD_1, U6.6
unnamed: R51.PAD_0, U6.8
unnamed: C28.PAD_1, U6.3
unnamed: C29.PAD_0, C30.MINUS, D7.ANODE, L5.1
unnamed: C31.PAD_0, C32.PLUS, D7.CATHODE, L6.1, R53.PAD_1
unnamed: R53.PAD_0, R54.PAD_1, U6.5
unnamed: R55.PAD_1, R56.PAD_1, U4.2
unnamed: D8.ANODE, R56.PAD_0, U4.1
unnamed: R58.PAD_0, T14.3
unnamed: R59.PAD_0, R61.PAD_1, X12.2
unnamed: C26.PLUS, R57.PAD_0, R58.PAD_1, U4.3
unnamed: C35.PAD_1, R61.PAD_0, T14.1, ZD6.CATHODE
unnamed: D8.CATHODE, R60.PAD_0
unnamed: C36.PAD_1, R62.PAD_1, T13.3
unnamed: R63.PAD_0, R64.PAD_1, T15.G, T16.G, ZD7.CATHODE
unnamed: T15.D, T15.D1, T15.D2, T15.D3, T15.D4, T16.D, T16.D1, T16.D2, T16.D3, T16.D4, X14.PAD1, X14.PAD2
unnamed: ZD7.ANODE, ZD8.CATHODE
unnamed: F3.PAD1, R63.PAD_1, X13.PAD1, X13.PAD2
unnamed: D10.CATHODE, R65.PAD_1
unnamed: R66.PAD_1, R67.PAD_1, U8.1
unnamed: D9.ANODE, T17.D, T17.D1, T17.D2, T17.D3, T17.D4, T18.D, T18.D1, T18.D2, T18.D3, T18.D4, X16.PAD1, X16.PAD2
unnamed: R69.PAD_0, T17.G
unnamed: R68.PAD_0, T18.G
unnamed: R73.PAD_0, R74.PAD_0, U7.5
unnamed: R73.PAD_1, R77.PAD_0, U7.7
unnamed: R71.PAD_0, R72.PAD_1, U7.6
unnamed: R75.PAD_0, R76.PAD_0, U7.10
unnamed: C42.PAD_1, R77.PAD_1, U7.9
unnamed: C42.PAD_0, R74.PAD_1, U7.8, U7.13
unnamed: C45.PAD_1, R78.PAD_1, R79.PAD_0, R91.PAD_1
unnamed: R78.PAD_0, X17.2
unnamed: R79.PAD_1, R80.PAD_0, U7.12
unnamed: R80.PAD_1, R81.PAD_0, U7.14
unnamed: R81.PAD_1, T19.1, T20.1
unnamed: R68.PAD_1, R69.PAD_1, R70.PAD_0, T19.2, T20.2
unnamed: L7.1, R82.PAD_1, R83.PAD_0, U9.7
unnamed: C47.PAD_1, C48.PLUS, L7.2, U9.1
unnamed: C38.PLUS, C40.PAD_1, R65.PAD_0, R83.PAD_1, U9.6
unnamed: R82.PAD_0, U9.8
unnamed: C46.PAD_1, U9.3
unnamed: C47.PAD_0, C48.MINUS, D11.ANODE, L8.1
unnamed: C49.PAD_0, C50.PLUS, D11.CATHODE, L9.1, R84.PAD_1
unnamed: R84.PAD_0, R85.PAD_1, U9.5
unnamed: R86.PAD_1, R87.PAD_1, U7.2
unnamed: D12.ANODE, R87.PAD_0, U7.1
unnamed: R89.PAD_0, T21.3
unnamed: R90.PAD_0, R92.PAD_1, X18.2
unnamed: C44.PLUS, R88.PAD_0, R89.PAD_1, U7.3
unnamed: C53.PAD_1, R92.PAD_0, T21.1, ZD9.CATHODE
unnamed: D12.CATHODE, R91.PAD_0
unnamed: C54.PAD_1, R93.PAD_1, T20.3
unnamed: R94.PAD_0, R95.PAD_1, T22.G, T23.G, ZD10.CATHODE
unnamed: T22.D, T22.D1, T22.D2, T22.D3, T22.D4, T23.D, T23.D1, T23.D2, T23.D3, T23.D4, X20.PAD1, X20.PAD2
unnamed: ZD10.ANODE, ZD11.CATHODE
unnamed: F4.PAD1, R94.PAD_1, X19.PAD1, X19.PAD2
unnamed: D14.CATHODE, R96.PAD_1
unnamed: R97.PAD_1, R98.PAD_1, U11.1
unnamed: D13.ANODE, T24.D, T24.D1, T24.D2, T24.D3, T24.D4, T25.D, T25.D1, T25.D2, T25.D3, T25.D4, X22.PAD1, X22.PAD2
unnamed: R100.PAD_0, T24.G
unnamed: R99.PAD_0, T25.G
unnamed: R104.PAD_0, R105.PAD_0, U10.5
unnamed: R104.PAD_1, R108.PAD_0, U10.7
unnamed: R102.PAD_0, R103.PAD_1, U10.6
unnamed: R106.PAD_0, R107.PAD_0, U10.10
unnamed: C60.PAD_1, R108.PAD_1, U10.9
unnamed: C60.PAD_0, R105.PAD_1, U10.8, U10.13
unnamed: C63.PAD_1, R109.PAD_1, R110.PAD_0, R122.PAD_1
unnamed: R109.PAD_0, X23.2
unnamed: R110.PAD_1, R111.PAD_0, U10.12
unnamed: R111.PAD_1, R112.PAD_0, U10.14
unnamed: R112.PAD_1, T26.1, T27.1
unnamed: R99.PAD_1, R100.PAD_1, R101.PAD_0, T26.2, T27.2
unnamed: L10.1, R113.PAD_1, R114.PAD_0, U12.7
unnamed: C65.PAD_1, C66.PLUS, L10.2, U12.1
unnamed: C56.PLUS, C58.PAD_1, R96.PAD_0, R114.PAD_1, U12.6
unnamed: R113.PAD_0, U12.8
unnamed: C64.PAD_1, U12.3
unnamed: C65.PAD_0, C66.MINUS, D15.ANODE, L11.1
unnamed: C67.PAD_0, C68.PLUS, D15.CATHODE, L12.1, R115.PAD_1
unnamed: R115.PAD_0, R116.PAD_1, U12.5
unnamed: R117.PAD_1, R118.PAD_1, U10.2
unnamed: D16.ANODE, R118.PAD_0, U10.1
unnamed: R120.PAD_0, T28.3
unnamed: R121.PAD_0, R123.PAD_1, X24.2
unnamed: C62.PLUS, R119.PAD_0, R120.PAD_1, U10.3
unnamed: C71.PAD_1, R123.PAD_0, T28.1, ZD12.CATHODE
unnamed: D16.CATHODE, R122.PAD_0
unnamed: C72.PAD_1, R124.PAD_1, T27.3

## EAGLE design SoftStartBoard/PotenciometersBoard/PotenciometersBoard.brd

Parts:
R1, R2, R3, R4: 10K; SP3-4AM
X1: REG1; PIN3X1_2.54MM_WITH_CLAMP
X2: REG2; PIN3X1_2.54MM_WITH_CLAMP
X3: REG3; PIN3X1_2.54MM_WITH_CLAMP
X4: REG4; PIN3X1_2.54MM_WITH_CLAMP
X5: REG1; PIN1X3_2.54MM_SIDE_BOARD
X6: REG2; PIN1X3_2.54MM_SIDE_BOARD
X7: REG3; PIN1X3_2.54MM_SIDE_BOARD
X8: REG4; PIN1X3_2.54MM_SIDE_BOARD

Connections:
GND: R1.PACKAGE1 (PACKAGE), R1.PACKAGE2 (PACKAGE), R2.PACKAGE1 (PACKAGE), R2.PACKAGE2 (PACKAGE), R3.PACKAGE1 (PACKAGE), R3.PACKAGE2 (PACKAGE), R4.PACKAGE1 (PACKAGE), R4.PACKAGE2 (PACKAGE)
unnamed: R1.END_B, X1.1, X5.1
unnamed: R1.MIDDLE, X1.2, X5.2
unnamed: R1.END_A, X1.3, X5.3
unnamed: R2.END_B, X2.1, X6.1
unnamed: R2.MIDDLE, X2.2, X6.2
unnamed: R2.END_A, X2.3, X6.3
unnamed: R3.END_B, X3.1, X7.1
unnamed: R3.MIDDLE, X3.2, X7.2
unnamed: R3.END_A, X3.3, X7.3
unnamed: R4.END_B, X4.1, X8.1
unnamed: R4.MIDDLE, X4.2, X8.2
unnamed: R4.END_A, X4.3, X8.3

Board: 2 copper layers, 100.0 x 43.0 mm, 12 parts (8 on the bottom side), 13 nets.

## EAGLE design SoftStartBoard/schematic/SoftStart_V2_0.brd

Parts:
C1, C4, C6: 47uFx25V; CE_6.3MM
C2: 1000uFx25V; CE_10MM
C3, C5, C7: 1.0uFx25V; RSMD_1206
C8: 0.1uFx25V; RSMD_0805
C9, C18: 22uFx16V; CE_6.3MM
C10: 470uFx25V; CE_10MM
C11: 0.1uFx25V; RSMD_1206
C12: 220pFx25V; RSMD_0805
C13, C14, C16, C17: 0.1uF x 16V; RSMD_0805
C15: 1nF x 16V; RSMD_0805
D1, D2, D3: B120; DO-214AC
D4: LL4148; SOD-80
F1: 20A; FUSE_AUTO_MINI_ON_TERMINALS
L1: 680uHx0.17A; LCHB0608
L2: 1.0mH x 0.05A; LCHB0608
L3: 680uH x 0.07A; LCHB0608
R1: 2K0; RSMD_0805
R2: 1K3; RSMD_0805
R3: 4K7; RSMD_0805
R4: 10R*; RSMD_1206_BIG_GAP
R5: 2R0; RSMD_1206_BIG_GAP
R6: 9K1; RSMD_0805
R7: 1K6; RSMD_0805
R8: 15K; RSMD_0805
R9: 47K; RSMD_0805
R10: 20R*; RSMD_1206
R11, R12, R19: 51K; RSMD_0805
R13: 1M0; RSMD_0805
R14: 13K; RSMD_0805
R15, R27, R28, R30: 5K1; RSMD_0805
R16: 8K2; RSMD_0805
R17: 82K; RSMD_0805
R18, R23, R25, R31: 10K; RSMD_0805
R20: 10K; RSMD_1206_BIG_GAP
R21, R22, R26: 20R; RSMD_0805
R24: 510K; RSMD_0805
R29: 20K; RSMD_0805
T1, T2, T5, T6: PK616BA; PDFN_5X6P
T3: BC847; SOT23
T4: BC857; SOT23
T7: 2N7002; SOT23
U1: AMS1117; SOT223(WAVE_SOLDERING)
U2: MC34063; SOIC8
U3: TP2274; SOIC14
X1: +12V; RPI_6.3
X2: GND; RPI_6.3
X3, X4: LAMP; RPI_6.3
X5: SET_DUTY_CYCLE(10K); PIN3X1_2.54MM_WITH_CLAMP
X6: ON/OFF; PIN2X1_2.54_WITH_CLAMP
ZD1, ZD2, ZD3: 5V6; SOD-80

Connections:
+10V: C8.PAD_1 (PIN1), C9.PLUS, C13.PAD_1 (PIN1), R2.PAD_0 (PIN0), R10.PAD_0 (PIN0), R11.PAD_1 (PIN1), R14.PAD_1 (PIN1), R23.PAD_1 (PIN1), R24.PAD_1 (PIN1), U1.2 (OUT), U1.4 (OUT), U3.4 (VCC), X5.1
+12V: C2.PLUS, D2.ANODE, D3.CATHODE, F1.PAD0 (PIN0), X3.PAD1, X3.PAD2
+13V_RAW: C6.PLUS, C7.PAD_0 (PIN0), L2.2 (END), U1.3 (IN)
GND: C2.MINUS, C4.MINUS, C5.PAD_1 (PIN1), C6.MINUS, C7.PAD_1 (PIN1), C8.PAD_0 (PIN0), C9.MINUS, C10.MINUS, C11.PAD_0 (PIN0), C12.PAD_0 (PIN0), C13.PAD_0 (PIN0), C14.PAD_0 (PIN0), C16.PAD_0 (PIN0), C17.PAD_0 (PIN0), C18.MINUS, L3.2 (END), R6.PAD_0 (PIN0), R7.PAD_0 (PIN0), R9.PAD_0 (PIN0), R12.PAD_1 (PIN1), R18.PAD_0 (PIN0), R25.PAD_1 (PIN1), R30.PAD_0 (PIN0), T1.S1 (SOURCE), T1.S2 (SOURCE), T1.S3 (SOURCE), T2.S1 (SOURCE), T2.S2 (SOURCE), T2.S3 (SOURCE), T4.3 (C), T5.S1 (SOURCE), T5.S2 (SOURCE), T5.S3 (SOURCE), T6.S1 (SOURCE), T6.S2 (SOURCE), T6.S3 (SOURCE), T7.2 (SOURCE), U2.2 (SW_E), U2.4 (GND), U3.11 (GND), X5.3, X6.1, ZD2.ANODE, ZD3.ANODE
unnamed: R3.PAD_0 (PIN0), R9.PAD_1 (PIN1), T1.G (GATE), T2.G (GATE), ZD1.CATHODE
unnamed: T1.D (DRAIN), T1.D1 (DRAIN), T1.D2 (DRAIN), T1.D3 (DRAIN), T1.D4 (DRAIN), T2.D (DRAIN), T2.D1 (DRAIN), T2.D2 (DRAIN), T2.D3 (DRAIN), T2.D4 (DRAIN), X2.PAD1, X2.PAD2
unnamed: ZD1.ANODE, ZD2.CATHODE
unnamed: F1.PAD1 (PIN1), R3.PAD_1 (PIN1), X1.PAD1, X1.PAD2
unnamed: L1.1 (START), R1.PAD_1 (PIN1), R5.PAD_0 (PIN0), U2.7 (I_PEAK)
unnamed: D2.CATHODE, R4.PAD_1 (PIN1)
unnamed: R2.PAD_1 (PIN1), R6.PAD_1 (PIN1), U1.1 (ADJ)
unnamed: D3.ANODE, T5.D (DRAIN), T5.D1 (DRAIN), T5.D2 (DRAIN), T5.D3 (DRAIN), T5.D4 (DRAIN), T6.D (DRAIN), T6.D1 (DRAIN), T6.D2 (DRAIN), T6.D3 (DRAIN), T6.D4 (DRAIN), X4.PAD1, X4.PAD2
unnamed: R22.PAD_0 (PIN0), T6.G (GATE)
unnamed: R21.PAD_0 (PIN0), T5.G (GATE)
unnamed: D4.CATHODE, R27.PAD_0 (PIN0)
unnamed: R17.PAD_0 (PIN0), R19.PAD_0 (PIN0), U3.5 (IN+)
unnamed: R16.PAD_0 (PIN0), R17.PAD_1 (PIN1), U3.7 (OUT)
unnamed: R14.PAD_0 (PIN0), R18.PAD_1 (PIN1), U3.6 (IN-)
unnamed: R29.PAD_1 (PIN1), R30.PAD_1 (PIN1), U3.2 (IN-)
unnamed: R11.PAD_0 (PIN0), R12.PAD_0 (PIN0), U3.10 (IN+)
unnamed: C15.PAD_1 (PIN1), R16.PAD_1 (PIN1), U3.9 (IN-)
unnamed: C15.PAD_0 (PIN0), R19.PAD_1 (PIN1), U3.8 (OUT), U3.13 (IN-)
unnamed: D4.ANODE, R29.PAD_0 (PIN0), U3.1 (OUT)
unnamed: C16.PAD_1 (PIN1), R20.PAD_0 (PIN0), R27.PAD_1 (PIN1), R28.PAD_1 (PIN1)
unnamed: C17.PAD_1 (PIN1), R31.PAD_0 (PIN0), T7.1 (GATE), ZD3.CATHODE
unnamed: R28.PAD_0 (PIN0), X5.2
unnamed: R13.PAD_0 (PIN0), R20.PAD_1 (PIN1), U3.12 (IN+)
unnamed: R13.PAD_1 (PIN1), R15.PAD_0 (PIN0), U3.14 (OUT)
unnamed: R15.PAD_1 (PIN1), T3.1 (B), T4.1 (B)
unnamed: R21.PAD_1 (PIN1), R22.PAD_1 (PIN1), R25.PAD_0 (PIN0), T3.2 (E), T4.2 (E)
unnamed: C14.PAD_1 (PIN1), R10.PAD_1 (PIN1), T3.3 (C)
unnamed: C1.PLUS, C3.PAD_1 (PIN1), L1.2 (END), U2.1 (SW_C)
unnamed: C1.MINUS, C3.PAD_0 (PIN0), D1.ANODE, L3.1 (START)
unnamed: C10.PLUS, C11.PAD_1 (PIN1), R4.PAD_0 (PIN0), R5.PAD_1 (PIN1), U2.6 (VCC)
unnamed: R1.PAD_0 (PIN0), U2.8 (DR_C)
unnamed: C12.PAD_1 (PIN1), U2.3 (CT)
unnamed: C4.PLUS, C5.PAD_0 (PIN0), D1.CATHODE, L2.1 (START), R8.PAD_1 (PIN1)
unnamed: R7.PAD_1 (PIN1), R8.PAD_0 (PIN0), U2.5 (INV_IN)
unnamed: R26.PAD_0 (PIN0), T7.3 (DRAIN)
unnamed: C18.PLUS, R24.PAD_0 (PIN0), R26.PAD_1 (PIN1), U3.3 (IN+)
unnamed: R23.PAD_0 (PIN0), R31.PAD_1 (PIN1), X6.2

Notes on the sheet:
+4.347V
Umin=0.832V
Umax=7.05V
+5V
50KHz_Saw_1.0_to_5.0V
0.0V to 2.0V rise
Trise ~2.86sec

Board: 2 copper layers, 60.0 x 60.0 mm, 76 parts (59 on the bottom side), 41 nets.
