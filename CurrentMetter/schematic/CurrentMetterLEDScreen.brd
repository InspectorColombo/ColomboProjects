# Repository InspectorColombo/ColomboProjects

## EAGLE design CurrentMetter/schematic/CurrentMetterLEDScreen.brd

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C9, C10, C11, C12: 0.1uF x 10V; RSMD_0603
C13: 100uF x 16V; CE_6.3MM_HOR_REVERTED
D1: B120; DO-214AC
DS1, DS2, DS3, DS4, DS5, DS6, DS7, DS8, DS9, DS10, DS11, DS12: KEM5161; KEM-5161(NARROW_PADS_OUTSIDE)
IC1, IC2, IC3, IC4, IC5, IC6, IC7, IC8, IC9, IC10, IC11, IC12: 74HC595D; SOIC16
J1, J2: JUMPER0805; RSMD_0805
KEY1: K1; KEY_7X4.5_BIG_PADS
KEY2: K2; KEY_7X4.5_BIG_PADS
KEY3: K3; KEY_7X4.5_BIG_PADS
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16, R17, R18, R19, R20, R21, R22, R23, R24, R25, R26, R27, R28, R29, R30, R31, R32, R33, R34, R35, R36, R37, R38, R39, R40, R41, R42, R43, R44, R45, R46, R47, R48, R49, R50, R51, R52, R53, R54, R55, R56, R57, R58, R59, R60, R61, R62, R63, R64, R65, R66, R67, R68, R69, R70, R71, R72, R73, R74, R75, R76, R77, R78, R79, R80, R81, R82, R83, R84, R85, R86, R87, R88, R89, R90, R91, R92, R93, R94, R95, R96, R97, R98, R99: 1K0; RSMD_0603
X1: SPI; PIN5X1_2.54MM_SIDE_BOARD
X1_1: SPI; PIN5X1_2.54MM_WITH_CLAMP
X2: KEYS; PIN1X3_2.54MM_SIDE_BOARD
X2_2: KEYS; PIN3X1_2.54MM_WITH_CLAMP

Connections:
+5V: C1.PAD_1 (PIN1), C2.PAD_1 (PIN1), C3.PAD_1 (PIN1), C4.PAD_1 (PIN1), C5.PAD_1 (PIN1), C6.PAD_1 (PIN1), C7.PAD_1 (PIN1), C8.PAD_1 (PIN1), C9.PAD_1 (PIN1), C10.PAD_1 (PIN1), C11.PAD_1 (PIN1), C12.PAD_1 (PIN1), C13.PLUS, D1.CATHODE, IC1.10 (~SER_RES), IC1.16 (VCC), IC2.10 (~SER_RES), IC2.16 (VCC), IC3.10 (~SER_RES), IC3.16 (VCC), IC4.10 (~SER_RES), IC4.16 (VCC), IC5.10 (~SER_RES), IC5.16 (VCC), IC6.10 (~SER_RES), IC6.16 (VCC), IC7.10 (~SER_RES), IC7.16 (VCC), IC8.10 (~SER_RES), IC8.16 (VCC), IC9.10 (~SER_RES), IC9.16 (VCC), IC10.10 (~SER_RES), IC10.16 (VCC), IC11.10 (~SER_RES), IC11.16 (VCC), IC12.10 (~SER_RES), IC12.16 (VCC), R97.PAD_1 (PIN1), R98.PAD_1 (PIN1), R99.PAD_1 (PIN1), X1.1, X1_1.1
DIG_CLK: IC1.11 (SER_CLK), IC2.11 (SER_CLK), IC3.11 (SER_CLK), IC4.11 (SER_CLK), IC5.11 (SER_CLK), IC6.11 (SER_CLK), IC7.11 (SER_CLK), IC8.11 (SER_CLK), IC9.11 (SER_CLK), IC10.11 (SER_CLK), IC11.11 (SER_CLK), IC12.11 (SER_CLK), J1.PAD_0, J1.PAD_1, X1.2, X1_1.2
DIG_DATA: IC9.14 (SER_IN), X1.4, X1_1.4
DIG_LATCH: IC1.12 (LATCH), IC2.12 (LATCH), IC3.12 (LATCH), IC4.12 (LATCH), IC5.12 (LATCH), IC6.12 (LATCH), IC7.12 (LATCH), IC8.12 (LATCH), IC9.12 (LATCH), IC10.12 (LATCH), IC11.12 (LATCH), IC12.12 (LATCH), J2.PAD_0, J2.PAD_1, X1.3, X1_1.3
GND: C1.PAD_0 (PIN0), C2.PAD_0 (PIN0), C3.PAD_0 (PIN0), C4.PAD_0 (PIN0), C5.PAD_0 (PIN0), C6.PAD_0 (PIN0), C7.PAD_0 (PIN0), C8.PAD_0 (PIN0), C9.PAD_0 (PIN0), C10.PAD_0 (PIN0), C11.PAD_0 (PIN0), C12.PAD_0 (PIN0), C13.MINUS, D1.ANODE, DS1.3 (COM), DS1.8 (COM), DS2.3 (COM), DS2.8 (COM), DS3.3 (COM), DS3.8 (COM), DS4.3 (COM), DS4.8 (COM), DS5.3 (COM), DS5.8 (COM), DS6.3 (COM), DS6.8 (COM), DS7.3 (COM), DS7.8 (COM), DS8.3 (COM), DS8.8 (COM), DS9.3 (COM), DS9.8 (COM), DS10.3 (COM), DS10.8 (COM), DS11.3 (COM), DS11.8 (COM), DS12.3 (COM), DS12.8 (COM), IC1.8 (GND), IC1.13 (~OE), IC2.8 (GND), IC2.13 (~OE), IC3.8 (GND), IC3.13 (~OE), IC4.8 (GND), IC4.13 (~OE), IC5.8 (GND), IC5.13 (~OE), IC6.8 (GND), IC6.13 (~OE), IC7.8 (GND), IC7.13 (~OE), IC8.8 (GND), IC8.13 (~OE), IC9.8 (GND), IC9.13 (~OE), IC10.8 (GND), IC10.13 (~OE), IC11.8 (GND), IC11.13 (~OE), IC12.8 (GND), IC12.13 (~OE), KEY1.3 (2), KEY1.4 (2), KEY2.3 (2), KEY2.4 (2), KEY3.3 (2), KEY3.4 (2), X1.5, X1_1.5
KEY1_LINE: KEY1.1, KEY1.2 (1), R99.PAD_0 (PIN0), X2.3, X2_2.3
KEY2_LINE: KEY2.1, KEY2.2 (1), R98.PAD_0 (PIN0), X2.2, X2_2.2
KEY3_LINE: KEY3.1, KEY3.2 (1), R97.PAD_0 (PIN0), X2.1, X2_2.1
unnamed: DS4.7 (A), R4.PAD_0 (PIN0)
unnamed: DS4.6 (B), R8.PAD_0 (PIN0)
unnamed: DS4.4 (C), R12.PAD_0 (PIN0)
unnamed: DS4.2 (D), R16.PAD_0 (PIN0)
unnamed: DS4.1 (E), R20.PAD_0 (PIN0)
unnamed: DS4.9 (F), R24.PAD_0 (PIN0)
unnamed: DS4.10 (G), R28.PAD_0 (PIN0)
unnamed: DS4.5 (DOT), R32.PAD_0 (PIN0)
unnamed: DS8.7 (A), R36.PAD_0 (PIN0)
unnamed: DS8.6 (B), R40.PAD_0 (PIN0)
unnamed: DS8.4 (C), R44.PAD_0 (PIN0)
unnamed: DS8.2 (D), R48.PAD_0 (PIN0)
unnamed: DS8.1 (E), R52.PAD_0 (PIN0)
unnamed: DS8.9 (F), R56.PAD_0 (PIN0)
unnamed: DS8.10 (G), R60.PAD_0 (PIN0)
unnamed: DS8.5 (DOT), R64.PAD_0 (PIN0)
unnamed: DS3.7 (A), R3.PAD_0 (PIN0)
unnamed: DS3.6 (B), R7.PAD_0 (PIN0)
unnamed: DS3.4 (C), R11.PAD_0 (PIN0)
unnamed: DS3.2 (D), R15.PAD_0 (PIN0)
unnamed: IC3.9 (SER_OUT), IC4.14 (SER_IN)
unnamed: DS3.1 (E), R19.PAD_0 (PIN0)
unnamed: DS3.9 (F), R23.PAD_0 (PIN0)
unnamed: DS3.10 (G), R27.PAD_0 (PIN0)
unnamed: DS3.5 (DOT), R31.PAD_0 (PIN0)
unnamed: IC2.9 (SER_OUT), IC3.14 (SER_IN)
unnamed: IC1.9 (SER_OUT), IC2.14 (SER_IN)
unnamed: DS7.7 (A), R35.PAD_0 (PIN0)
unnamed: DS7.6 (B), R39.PAD_0 (PIN0)
unnamed: DS7.4 (C), R43.PAD_0 (PIN0)
unnamed: DS7.2 (D), R47.PAD_0 (PIN0)
unnamed: DS7.1 (E), R51.PAD_0 (PIN0)
unnamed: DS7.9 (F), R55.PAD_0 (PIN0)
unnamed: DS7.10 (G), R59.PAD_0 (PIN0)
unnamed: DS7.5 (DOT), R63.PAD_0 (PIN0)
unnamed: DS2.7 (A), R2.PAD_0 (PIN0)
unnamed: DS2.6 (B), R6.PAD_0 (PIN0)
unnamed: DS2.4 (C), R10.PAD_0 (PIN0)
unnamed: DS2.2 (D), R14.PAD_0 (PIN0)
unnamed: DS2.1 (E), R18.PAD_0 (PIN0)
unnamed: DS2.9 (F), R22.PAD_0 (PIN0)
unnamed: DS2.10 (G), R26.PAD_0 (PIN0)
unnamed: DS2.5 (DOT), R30.PAD_0 (PIN0)
unnamed: DS6.7 (A), R34.PAD_0 (PIN0)
unnamed: DS6.6 (B), R38.PAD_0 (PIN0)
unnamed: DS6.4 (C), R42.PAD_0 (PIN0)
unnamed: DS6.2 (D), R46.PAD_0 (PIN0)
unnamed: DS6.1 (E), R50.PAD_0 (PIN0)
unnamed: DS6.9 (F), R54.PAD_0 (PIN0)
unnamed: DS6.10 (G), R58.PAD_0 (PIN0)
unnamed: DS6.5 (DOT), R62.PAD_0 (PIN0)
unnamed: DS5.7 (A), R33.PAD_0 (PIN0)
unnamed: DS1.7 (A), R1.PAD_0 (PIN0)
unnamed: DS1.6 (B), R5.PAD_0 (PIN0)
unnamed: DS1.4 (C), R9.PAD_0 (PIN0)
unnamed: DS1.2 (D), R13.PAD_0 (PIN0)
unnamed: DS1.1 (E), R17.PAD_0 (PIN0)
unnamed: DS1.9 (F), R21.PAD_0 (PIN0)
unnamed: DS1.10 (G), R25.PAD_0 (PIN0)
unnamed: DS1.5 (DOT), R29.PAD_0 (PIN0)
unnamed: DS5.6 (B), R37.PAD_0 (PIN0)
unnamed: DS5.4 (C), R41.PAD_0 (PIN0)
unnamed: DS5.2 (D), R45.PAD_0 (PIN0)
unnamed: DS5.1 (E), R49.PAD_0 (PIN0)
unnamed: DS5.9 (F), R53.PAD_0 (PIN0)
unnamed: DS5.10 (G), R57.PAD_0 (PIN0)
unnamed: DS5.5 (DOT), R61.PAD_0 (PIN0)
unnamed: IC7.9 (SER_OUT), IC8.14 (SER_IN)
unnamed: IC6.9 (SER_OUT), IC7.14 (SER_IN)
unnamed: IC5.9 (SER_OUT), IC6.14 (SER_IN)
unnamed: DS12.7 (A), R68.PAD_0 (PIN0)
unnamed: DS12.6 (B), R72.PAD_0 (PIN0)
unnamed: DS12.4 (C), R76.PAD_0 (PIN0)
unnamed: DS12.2 (D), R80.PAD_0 (PIN0)
unnamed: DS12.1 (E), R84.PAD_0 (PIN0)
unnamed: DS12.9 (F), R88.PAD_0 (PIN0)
unnamed: DS12.10 (G), R92.PAD_0 (PIN0)
unnamed: DS12.5 (DOT), R96.PAD_0 (PIN0)
unnamed: DS11.7 (A), R67.PAD_0 (PIN0)
unnamed: DS11.6 (B), R71.PAD_0 (PIN0)
unnamed: DS11.4 (C), R75.PAD_0 (PIN0)
unnamed: DS11.2 (D), R79.PAD_0 (PIN0)
unnamed: DS11.1 (E), R83.PAD_0 (PIN0)
unnamed: DS11.9 (F), R87.PAD_0 (PIN0)
unnamed: DS11.10 (G), R91.PAD_0 (PIN0)
unnamed: DS11.5 (DOT), R95.PAD_0 (PIN0)
unnamed: DS10.7 (A), R66.PAD_0 (PIN0)
unnamed: DS10.6 (B), R70.PAD_0 (PIN0)
unnamed: DS10.4 (C), R74.PAD_0 (PIN0)
unnamed: DS10.2 (D), R78.PAD_0 (PIN0)
unnamed: DS10.1 (E), R82.PAD_0 (PIN0)
unnamed: DS10.9 (F), R86.PAD_0 (PIN0)
unnamed: DS10.10 (G), R90.PAD_0 (PIN0)
unnamed: DS10.5 (DOT), R94.PAD_0 (PIN0)
unnamed: DS9.7 (A), R65.PAD_0 (PIN0)
unnamed: DS9.6 (B), R69.PAD_0 (PIN0)
unnamed: DS9.4 (C), R73.PAD_0 (PIN0)
unnamed: DS9.2 (D), R77.PAD_0 (PIN0)
unnamed: DS9.1 (E), R81.PAD_0 (PIN0)
unnamed: DS9.9 (F), R85.PAD_0 (PIN0)
unnamed: DS9.10 (G), R89.PAD_0 (PIN0)
unnamed: DS9.5 (DOT), R93.PAD_0 (PIN0)
unnamed: IC11.9 (SER_OUT), IC12.14 (SER_IN)
unnamed: IC10.9 (SER_OUT), IC11.14 (SER_IN)
unnamed: IC9.9 (SER_OUT), IC10.14 (SER_IN)
unnamed: IC1.14 (SER_IN), IC8.9 (SER_OUT)
unnamed: IC5.14 (SER_IN), IC12.9 (SER_OUT)
SR1_D0: IC4.15 (QA), R29.PAD_1 (PIN1)
SR1_D1: IC4.1 (QB), R9.PAD_1 (PIN1)
SR1_D2: IC4.2 (QC), R13.PAD_1 (PIN1)
SR1_D3: IC4.3 (QD), R17.PAD_1 (PIN1)
SR1_D4: IC4.4 (QE), R25.PAD_1 (PIN1)
SR1_D5: IC4.5 (QF), R21.PAD_1 (PIN1)
SR1_D6: IC4.6 (QG), R5.PAD_1 (PIN1)
SR1_D7: IC4.7 (QH), R1.PAD_1 (PIN1)
SR2_D0: IC3.15 (QA), R30.PAD_1 (PIN1)
SR2_D1: IC3.1 (QB), R10.PAD_1 (PIN1)
SR2_D2: IC3.2 (QC), R14.PAD_1 (PIN1)
SR2_D3: IC3.3 (QD), R18.PAD_1 (PIN1)
SR2_D4: IC3.4 (QE), R26.PAD_1 (PIN1)
SR2_D5: IC3.5 (QF), R22.PAD_1 (PIN1)
SR2_D6: IC3.6 (QG), R6.PAD_1 (PIN1)
SR2_D7: IC3.7 (QH), R2.PAD_1 (PIN1)
SR3_D0: IC2.15 (QA), R31.PAD_1 (PIN1)
SR3_D1: IC2.1 (QB), R11.PAD_1 (PIN1)
SR3_D2: IC2.2 (QC), R15.PAD_1 (PIN1)
SR3_D3: IC2.3 (QD), R19.PAD_1 (PIN1)
SR3_D4: IC2.4 (QE), R27.PAD_1 (PIN1)
SR3_D5: IC2.5 (QF), R23.PAD_1 (PIN1)
SR3_D6: IC2.6 (QG), R7.PAD_1 (PIN1)
SR3_D7: IC2.7 (QH), R3.PAD_1 (PIN1)
SR4_D0: IC1.15 (QA), R32.PAD_1 (PIN1)
SR4_D1: IC1.1 (QB), R12.PAD_1 (PIN1)
SR4_D2: IC1.2 (QC), R16.PAD_1 (PIN1)
SR4_D3: IC1.3 (QD), R20.PAD_1 (PIN1)
SR4_D4: IC1.4 (QE), R28.PAD_1 (PIN1)
SR4_D5: IC1.5 (QF), R24.PAD_1 (PIN1)
SR4_D6: IC1.6 (QG), R8.PAD_1 (PIN1)
SR4_D7: IC1.7 (QH), R4.PAD_1 (PIN1)
SR5_D0: IC5.15 (QA), R57.PAD_1 (PIN1)
SR5_D1: IC5.1 (QB), R53.PAD_1 (PIN1)
SR5_D2: IC5.2 (QC), R33.PAD_1 (PIN1)
SR5_D3: IC5.3 (QD), R37.PAD_1 (PIN1)
SR5_D4: IC5.4 (QE), R61.PAD_1 (PIN1)
SR5_D5: IC5.5 (QF), R41.PAD_1 (PIN1)
SR5_D6: IC5.6 (QG), R49.PAD_1 (PIN1)
SR5_D7: IC5.7 (QH), R45.PAD_1 (PIN1)
SR6_D0: IC6.15 (QA), R58.PAD_1 (PIN1)
SR6_D1: IC6.1 (QB), R54.PAD_1 (PIN1)
SR6_D2: IC6.2 (QC), R34.PAD_1 (PIN1)
SR6_D3: IC6.3 (QD), R38.PAD_1 (PIN1)
SR6_D4: IC6.4 (QE), R62.PAD_1 (PIN1)
SR6_D5: IC6.5 (QF), R42.PAD_1 (PIN1)
SR6_D6: IC6.6 (QG), R50.PAD_1 (PIN1)
SR6_D7: IC6.7 (QH), R46.PAD_1 (PIN1)
SR7_D0: IC7.15 (QA), R59.PAD_1 (PIN1)
SR7_D1: IC7.1 (QB), R55.PAD_1 (PIN1)
SR7_D2: IC7.2 (QC), R35.PAD_1 (PIN1)
SR7_D3: IC7.3 (QD), R39.PAD_1 (PIN1)
SR7_D4: IC7.4 (QE), R63.PAD_1 (PIN1)
SR7_D5: IC7.5 (QF), R43.PAD_1 (PIN1)
SR7_D6: IC7.6 (QG), R51.PAD_1 (PIN1)
SR7_D7: IC7.7 (QH), R47.PAD_1 (PIN1)
SR8_D0: IC8.15 (QA), R60.PAD_1 (PIN1)
SR8_D1: IC8.1 (QB), R56.PAD_1 (PIN1)
SR8_D2: IC8.2 (QC), R36.PAD_1 (PIN1)
SR8_D3: IC8.3 (QD), R40.PAD_1 (PIN1)
SR8_D4: IC8.4 (QE), R64.PAD_1 (PIN1)
SR8_D5: IC8.5 (QF), R44.PAD_1 (PIN1)
SR8_D6: IC8.6 (QG), R52.PAD_1 (PIN1)
SR8_D7: IC8.7 (QH), R48.PAD_1 (PIN1)
SR9_D0: IC12.15 (QA), R93.PAD_1 (PIN1)
SR9_D1: IC12.1 (QB), R73.PAD_1 (PIN1)
SR9_D2: IC12.2 (QC), R77.PAD_1 (PIN1)
SR9_D3: IC12.3 (QD), R81.PAD_1 (PIN1)
SR9_D4: IC12.4 (QE), R89.PAD_1 (PIN1)
SR9_D5: IC12.5 (QF), R85.PAD_1 (PIN1)
SR9_D6: IC12.6 (QG), R69.PAD_1 (PIN1)
SR9_D7: IC12.7 (QH), R65.PAD_1 (PIN1)
SR10_D0: IC11.15 (QA), R94.PAD_1 (PIN1)
SR10_D1: IC11.1 (QB), R74.PAD_1 (PIN1)
SR10_D2: IC11.2 (QC), R78.PAD_1 (PIN1)
SR10_D3: IC11.3 (QD), R82.PAD_1 (PIN1)
SR10_D4: IC11.4 (QE), R90.PAD_1 (PIN1)
SR10_D5: IC11.5 (QF), R86.PAD_1 (PIN1)
SR10_D6: IC11.6 (QG), R70.PAD_1 (PIN1)
SR10_D7: IC11.7 (QH), R66.PAD_1 (PIN1)
SR11_D0: IC10.15 (QA), R95.PAD_1 (PIN1)
SR11_D1: IC10.1 (QB), R75.PAD_1 (PIN1)
SR11_D2: IC10.2 (QC), R79.PAD_1 (PIN1)
SR11_D3: IC10.3 (QD), R83.PAD_1 (PIN1)
SR11_D4: IC10.4 (QE), R91.PAD_1 (PIN1)
SR11_D5: IC10.5 (QF), R87.PAD_1 (PIN1)
SR11_D6: IC10.6 (QG), R71.PAD_1 (PIN1)
SR11_D7: IC10.7 (QH), R67.PAD_1 (PIN1)
SR12_D0: IC9.15 (QA), R96.PAD_1 (PIN1)
SR12_D1: IC9.1 (QB), R76.PAD_1 (PIN1)
SR12_D2: IC9.2 (QC), R80.PAD_1 (PIN1)
SR12_D3: IC9.3 (QD), R84.PAD_1 (PIN1)
SR12_D4: IC9.4 (QE), R92.PAD_1 (PIN1)
SR12_D5: IC9.5 (QF), R88.PAD_1 (PIN1)
SR12_D6: IC9.6 (QG), R72.PAD_1 (PIN1)
SR12_D7: IC9.7 (QH), R68.PAD_1 (PIN1)

Board: 2 copper layers, 64.0 x 100.0 mm, 146 parts (128 on the bottom side), 211 nets.

## EAGLE design CurrentMetter/schematic/CurrentMetter.brd

Parts:
C1: 470uFx25V; CE_6.3MM
C2, C4, C6, C7, C8, C9: 0.1uF; RSMD_0805
C3: 10uFx16V; CE_5.2MM
C5: 10nF; RSMD_0805
D1, D2: 1N4001; DO-41_10MM
D3, D4, D5: LL4148; SOD-80
IC1: LM317; D2PAK
IC2: 74HC595; SOIC16
IC3: ATTINY45; SOIC8(0.15'')
LED1, LED8: RED; LED3MM
LED2, LED7: GREEN; LED3MM
LED3, LED4, LED5, LED6: YELLOW; LED3MM
R1: 1K0; RSMD_1206
R2, R3, R4, R5, R6, R7, R9, R10, R11: 1K0; RSMD_0805
R8: 3K0; RSMD_0805
R12: 10K; RSMD_1206_BIG_GAP
R13: 3K3; RSMD_0805
R14: 10K; RSMD_0805
R15: 4K7; RSMD_0805
R16: 0.1Ohm; R_1.0W
X1: VCC_IN; PIN1X1_3.5MM_SIDE_BOARD
X2: CHARGE_IN; PIN1X1_3.5MM_SIDE_BOARD
X3: GND_TO_ACC; PIN1X1_3.5MM_SIDE_BOARD
X4: GND_FROM_CHARGE; PIN1X1_3.5MM_SIDE_BOARD

Connections:
+5V: C3.PLUS, C4.PAD_0 (PIN0), C6.PAD_0 (PIN0), C9.PAD_0 (PIN0), D3.CATHODE, D4.CATHODE, IC1.2 (OUT), IC2.10 (~SER_RES), IC2.16 (VCC), IC3.8 (VCC), R3.PAD_1 (PIN1), R15.PAD_0 (PIN0)
GND: C1.MINUS, C2.PAD_1 (PIN1), C3.MINUS, C4.PAD_1 (PIN1), C5.PAD_1 (PIN1), C6.PAD_1 (PIN1), C7.PAD_1 (PIN1), C8.PAD_1 (PIN1), C9.PAD_1 (PIN1), D5.ANODE, IC2.8 (GND), IC2.13 (~OE), IC3.2 (PB3(ADC3/~OC1B/CLKI/XTAL1/PCINT3)), IC3.4 (GND), LED1.CATHODE, LED2.CATHODE, LED3.CATHODE, LED4.CATHODE, LED5.CATHODE, LED6.CATHODE, LED7.CATHODE, LED8.CATHODE, R8.PAD_0 (PIN0), R13.PAD_0 (PIN0), R16.PAD1 (PIN1), X4.1
I_SHUNT_ADC: C8.PAD_0 (PIN0), D4.ANODE, D5.CATHODE, IC3.3 (PB4(ADC2/OC1B/CLKO/XTAL2/PCINT4)), R14.PAD_1 (PIN1)
LED_DATA: IC2.14 (SER_IN), IC3.5 (PB0(MOSI/DI/SDA/AIN0/OC0A/~OC1A/AREF/PC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)
LED_LATCH: C5.PAD_0 (PIN0), IC2.12 (LATCH), R6.PAD_1 (PIN1)
LED_SCK: IC2.11 (SER_CLK), IC3.6 (PB1(MISO/DO/AIN1/OC0B/OC1A/PCINT1)), R6.PAD_0 (PIN0)
unnamed: IC2.6 (QG), R10.PAD_0 (PIN0)
unnamed: IC2.7 (QH), R11.PAD_0 (PIN0)
unnamed: LED7.ANODE, R10.PAD_1 (PIN1)
unnamed: LED4.ANODE, R5.PAD_1 (PIN1)
unnamed: IC3.1 (PB5(DW/ADC0/~RESET/PCINT5)), R15.PAD_1 (PIN1)
unnamed: C1.PLUS, C2.PAD_0 (PIN0), D1.CATHODE, D2.CATHODE, IC1.3 (IN)
unnamed: LED1.ANODE, R1.PAD_1 (PIN1)
unnamed: LED3.ANODE, R4.PAD_1 (PIN1)
unnamed: LED6.ANODE, R9.PAD_1 (PIN1)
unnamed: LED8.ANODE, R11.PAD_1 (PIN1)
unnamed: LED2.ANODE, R2.PAD_1 (PIN1)
unnamed: LED5.ANODE, R7.PAD_1 (PIN1)
unnamed: IC2.15 (QA), R1.PAD_0 (PIN0)
unnamed: IC2.1 (QB), R2.PAD_0 (PIN0)
unnamed: IC2.2 (QC), R4.PAD_0 (PIN0)
unnamed: IC2.3 (QD), R5.PAD_0 (PIN0)
unnamed: IC2.4 (QE), R7.PAD_0 (PIN0)
unnamed: IC2.5 (QF), R9.PAD_0 (PIN0)
unnamed: R14.PAD_0 (PIN0), R16.PAD_0 (PIN0), X3.1
unnamed: D1.ANODE, R12.PAD_0 (PIN0), X1.1
unnamed: D2.ANODE, X2.1
unnamed: IC1.1 (ADJ), R3.PAD_0 (PIN0), R8.PAD_1 (PIN1)
VOLTAGE_ADC: C7.PAD_0 (PIN0), D3.ANODE, IC3.7 (PB2(SCK/USCK/SCL/ADC1/T0/INT0/PCINT2)), R12.PAD_1 (PIN1), R13.PAD_1 (PIN1)

Board: 2 copper layers, 52.0 x 50.0 mm, 45 parts (32 on the bottom side), 29 nets.

## Commit log (part)

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2022-08-27 first version of USB ASP based on atmega8535
2022-08-27 Some level converter values were changed for improve data transfer speed
2022-08-27 Change again some element valus for correct working on high SCK speed. Remove jumper and add switch for low/high speed selection
2022-08-27 Sw for ATMega8535. Use original mega8 software, reconfigure according new pins. Switch off HW SPI, because of incorrect board routing. Fix SW SPI bug, when SCK_/~ and MOSI were changed almost in same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
2022-08-27 Switch solution from AVR-XC8 compiller to GCC, to allow code size optimization. Remove garbage from code. Modify POstBuild events to work with relative paths. Add /misc/ folder with odd byte bug comp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
2022-08-27 Add EAGLE libraries
2022-08-27 EAGLE libraries remove garbage files
2022-08-27 Pony prog based programmer
2022-08-27 UsbTinyISP add
2022-08-27 USB tiny ISP first solution, based on old project
2022-08-27 USBTinyISP switched to GCC compiller to fit in attiny2313 flash
2022-08-27 First USBTinyISP solution, based on old tiny ISP project. Software base ISP only. Full speed programming doesn't work, need to optimize schematic or sw
2022-08-30 Remove garbage code. Rewrite SPI routine for more correct timing of signals set. Remove unsupported USB commands, like Set/Clear bit in port, change DDR etc.
2022-08-31 Switch SW SPI to ASM. Draft variant. Write speed improved about 1.5 times
2022-09-03 Add 10 to 6 pins converter
2022-09-03 test2
2022-09-03 test
2022-09-03 remove garbage
2022-09-03 add other changes from Virtual Machine
2022-09-04 TinyISP. Fix micro usb incorrect pinout. Change transystor levels converter to fast, diode based. Route PCB.
2022-09-07 Switch SPI from SW to USI HW based. Implement fastest(3MHZ clk) SPI on ASM, and slow SPI on c
2022-09-10 LED Screen old firmware
2023-02-01 test3
2023-02-01 Add LC meter.
2023-02-04 LMeter new changes
2023-02-05 LCMeter Another changes
2023-02-07 LCMeter schematic is almost complete
2023-02-08 LCMeter start routing
2023-02-09 LCMeter routing
2023-02-11 LCMeter start routing2
2023-02-12 LCMeter start routing4
2023-02-12 LCMeter start routing 5
2023-02-12 LCMeter Route finish 1
2023-02-12 LCMeter Route finished
2023-02-18 L saturation meter
2023-02-18 Fix inconsistancy error
2023-02-18 Fix CE packages pads naming, to avoid inconsistance after package change
2023-02-19 Start routing
2023-02-19 L saturation metter routed
2023-02-22 L saturation meter. Ver2 schematic complete
2023-02-22 L saturation meter. Parts locating
2023-02-23 L saturation meter. Routing step 1
2023-02-23 L saturation meter. Routing step 2
2023-02-24 L saturation meter. Routed
2023-02-24 L saturation meter. tiny fixes
2023-02-25 L saturation meter. Final changes
2023-02-28 add inductor photos
2023-03-02 LC meter test power supply inverter
2023-03-02 LC meter test power supply inverter. parts Located
2023-03-02 LC meter test power supply inverter. almost routed
2023-03-04 LC_METER power supply ver2
2023-03-05 PoverInverter_V2
2023-03-05 PowerInverter_V2
2023-03-05 PowerInverter_V2 PCB routed
2023-03-14 LC meter schematic. Power stabilizer values fix
2023-03-14 Test LC meter power supply changes
2023-03-16 LC Meter change some values
2023-03-17 LC Metter start with software
2023-03-18 LED indicator routines done
2023-03-18 LC-metter. Timers and PWMs configured
2023-03-18 LC Metter. Add Keys pressing routines and anti jitter timer interrupt
2023-03-19 LC Metter. Battery voltage metter sw coded. Add ADC hysteresys routines
2023-03-19 LC Meter. Battery voltage metter resistors values changed
2023-03-19 LC Metter. Adjust +5v stabilizer values
2023-05-07 Current sensor
2023-05-07 test4
2023-05-07 Curent sensor. Half routed
2023-05-07 Curent sensor. Routed.
2023-05-08 Current sensor. PBC finally routed
2023-05-09 Current sensor metter SW start
2023-05-10 Current sensor. ADC switched to unipolar, all factors configured.
2023-05-10 LEDs configured for a half.
2023-05-11 LEDs configured. Voltage/current levels confiureconfigured.
2023-05-11 Flashing semi-configured.
2023-05-12 CurrentSensor almost finished.
2023-11-18 KLine adapter start
2023-11-19 KLine adapter
2023-11-19 KLine adapter. Schematic done.
2023-11-19 KLine adapter. Almost routed.
2023-11-23 KLine adapter. Routed.
2023-11-26 KLine adapter complete.
2023-11-26 12 to 200V inverter start.
2023-11-26 12 to 200V inverter. Routed.
2023-12-08 12 to 200V converter v2. Forward 2 conversion.
2023-12-09 12 to 200V converter v2. Schematic done.
2023-12-09 12 to 200V converter v2. Routed.
2023-12-27 12 to 200VDC converter. Ver3. Converter schematic done. Add overcurrent/overvoltage protection.
2024-01-02 12 to 200VDC converter. Ver3. Start with battery charger.
2024-01-02 12_to_200V inverter. Add new elements to libary.
2024-01-02 12_to_200V inverter. Ver3 Start schematic.
2024-01-04 12 to 200V converter. Ver3. Schematic almost done.
2024-01-05 12 to 200V converter. Ver3. Start routing.
2024-01-05 12 to 200V converter. Ver3. Renumber schematic.
2024-01-06 12 to 200V converter. Ver3. Slightly rebuild schematic. Charger, converter and indicator are separate now.
2024-01-06 12 to 200V converter. Ver3. Rebuilt schematic.
2024-01-06 12 to 200V converter. Ver3.
2024-01-07 12 to 200V converter. Ver3. Start simplification.
2024-01-07 12 to 200V converter. Ver3. Routing.
2024-01-11 12 to 200V converter
2024-01-12 10 to 200V inverter. Ver3. Routing.
2024-01-13 12 to 200V inverter. Almost routed.
2024-01-16 12 to 200V inverter. Some fixes.
2024-01-17 12 to 200V converter. Start sw.
2024-01-17 12 to 200V converter. Tiny fixes to chematic.
2024-01-17 12 to 200V converter. Rename LEDs.
2024-01-17 12 to 200V converter. Shift registers SPI configured. Leds/other perepheria configured.
2024-01-19 12 to 200v converter. SW USART writtedone for debug.
2024-01-20 12 to 200V converter. Adjust voltage ADC.
2024-01-20 12 to 200V converter. Voltage/Current ADC ration, offset error implemented.
2024-01-21 12 to 200V converter. Fix chematic(charger mostly) after tests on real border.
2024-01-23 12 to 200V converter. Fix instacharger startup/instability on low load. Add dummy load.
2024-01-24 12 to 200V converter. Prepared sw main routines.
2024-01-27 12 to 200V conv. sw.
2024-01-28 12 to 200V converter. Switch from C to C++.
2024-01-28 12 to 200V converter. Overwrite LED voltage/current indicators.
2024-01-29 12 to 200V converter. Fixed fast switching detection bug.
2024-01-31 12 to 200V inverter. Tiny schematic changes.
2024-02-11 12 to 200V inverter. Finish sw. But looks to ugly and big.
2024-02-11 12 to 200V inverter. Switch blinking to table definition. Works version.
2024-02-11 12 to 200V inverter. Move LEDs control to hpp, save 300 bytes flash. This version worksversion.
2024-02-17 12 to 200V inverter. Sw tiny changes.
2024-02-17 12 to 200V inverter. Folders clean from garbage.
2024-02-18 12 to 200V inverter. Add low battery warning hysteresis.
2024-02-27 12 to 200V inverter. Tiny SW change. Add charge finish beep. Disable additional charge voltage, if any lamp is ON, to avoid battery boiling.
2024-02-28 12 to 200V converter. Do some clean up.
2024-03-09 12 to 200V converter. Package.
2024-03-10 10 to 200V inverter. Package.
2024-03-10 10 to 200V inverter. Almost done.
2024-03-17 12 to 200V inverter. Package ver2.
2024-03-21 12 TO 200V inverter. Package.
2024-03-21 12 to 200V inverter. Package, CAP finished.
2024-03-21 12 to 200V inverter. Package almost finished. Holes for cooling and solid ribs left.
2024-03-22 12 to 200V inverter. Add cooling holes. Remove stl garbage.
2024-03-22 12 to 200V converter. Main package final.
2024-03-26 12 to 200V inverter. Change battery holder package. Change lamps holder board.
2024-03-28 12 to 200V inverter. Final package changes.
2024-03-28 12 to 200V inverter. Add separate indication board. Change erar CAP to support board instalation. Change power connector on CAP to BARREL type.
2024-04-01 12 to 200V inverter. Ring Holder stl.
2024-04-01 12 to 200V inverter. Remove garbage files.
2024-04-01 Update lib.
2024-04-04 12 to 200V inverter. Back cap update.
2024-04-13 12 to 200V inverter. Add changes to package. Correct PBC holder, hole depth for screws, bat holder. Enlarge tighteness ribs on walls. etc.
2024-05-01 12 to 200V inverter. Some package changes.
2024-05-01 12 to 200V inverter. New board with ETD transformers. Route.
2024-05-05 12 to 200V inverter. New board with ETD transformers. Finally routed.
2024-05-11 12 to 200V inverter. Change leds holder and board. board 160mm length. LEDs holder - add screw holes, change geometry size.
2024-05-11 12 to 200V inverter. Timny changes to schematic and board.
2024-05-20 recovery files.
2024-05-27 12 to 200V inverter. Last steps.
2024-05-31 12 to 200V inverter. Change SW to 2.4A charge current and modified current sensor block.
2024-05-31 12 to 200V inverter. Correct schematic values for correct charge voltages. For 2.4A charge current version. Remove some garbage.
2024-06-04 12 to 200V inverter. Update transformers data.
2024-06-04 12 to 200V inverter. Adjust current sensor indication and high to low voltage charger threshold.
2024-06-04 Filament Case drawning.
2024-06-09 Filament case.
2024-06-09 Filament case. Remove garbage.
2024-06-18 Niddle box.
2024-06-19 Niddle box. Fix lower curvage problem area.
2024-06-22 12 to 200V inverter. Lamp. Last package drawning.
2024-07-22 Canister Cap.
2024-07-23 CanisterCap last version.
2024-07-26 Humidity Metter. Add sw for stl32f103c8t6.
2024-07-26 Humidity Metter. Fix timer1 delay bug.
2024-07-26 Humidity Metter. LCD initialisation bug fixed..
2024-07-28 Humidity Metter. Humidity sensor finally connected and returns proper values.
2024-07-29 STM32F103C8T6 add to eagle lib.
2024-07-29 LCD 0802B added to lib.
2024-07-29 Humidity metter. Start schematic creation.
2024-07-30 Humidity metter. Start schematic routing.
2024-08-06 Humidity metter.
2024-08-06 Humidity metter. Routing.
2024-08-07 Himidity metter. Board routed.
2024-08-08 Himidity metter. Board routed. Fix tiny problems.
2024-08-15 Humidity metter. Move sensor code in separate file. Add time out power OFF.
2024-08-24 Humidity metter. BME280 code done(draft version).
2024-08-24 Humidity metter. BME280 clean up code.
2024-08-25 Humidity metter. Add key reading and switching between temp, humidity, preassure and battery voltage(dummy).
2024-08-26 Humidity metter. Package drawn.
2024-08-27 Humidity metter. Package.
2024-08-27 Humidity metter package.
2024-08-28 Lotok.
2024-09-01 Humidity metter. Add altitude metter option..
2024-09-01 Humidity metter sw.
2024-09-07 Lotok. Package.
2024-09-13 inverter package
2024-09-13 lotok
2024-09-29 Kassy.
2024-11-14 Test new token.
2024-11-15 test.
2024-12-08 Kassy. update.
2024-12-11 Kassy. Remove 0.2mm height.
2024-12-28 Humidity metter. Rewrite board.
2024-12-30 Humidity metter v2. Change schematic/board.
2024-12-31 Humidity metter v2. Change schematic/board 2.
2025-01-02 Humidity metter v2. Change schematic/board 3.
2025-01-03 Humidity metter v2. Change schematic/board 4.
2025-01-04 Humidity metter v2. Change schematic/board 5.
2025-01-04 Humidity metter. ver2. SW start.
2025-01-08 Humidity metter. Remove garbage,
2025-01-11 Humidity metter. Sensor holder board.
2025-01-13 HM. Make probe holder. SW - add SSD1306 I2C OLED display driver.
2025-01-17 Humidity metter. Rewrite SW I2C. Optimize it. Create SSD1306 OLED screen driver.
2025-01-17 Humidity metter. Clear Garbage.
2025-01-17 Humidity metter. Move BME280 to new fast SW I2C.
2025-01-17 Humidity metter. Move AM2320 sensor to new fast SW I2C.
2025-01-18 Humidity metter. Move SSD1306 class to fully template.
2025-01-18 Humidity metter. Move SSD1306 class modify.
2025-01-18 Humidity metter. Add Portrait orientation and vertical print for SSD1306.
2025-01-25 Humidity Metter. Ver2. SSD1306 Print class implemented.
2026-04-12 Some old changes with fonts.
2026-04-12 PS 1600W Current restriction board.
2026-04-13 PS 1600W Current restriction board. Route done.
2026-05-21 PS1600W. Current restriction board.
2026-06-05 Soft start board.
2026-06-13 SoftStart. Almost routed PCB.
2026-06-13 SoftStart. Routed PCB.
