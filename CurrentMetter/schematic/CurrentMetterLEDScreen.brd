# Repository InspectorColombo/ColomboProjects (continued)

## EAGLE design SWR_Metter/schematic/SwrMetter.brd

Parts:
A1: 50uA; MICRO_AMPMET(UNKNOWN)
C1, C2, C4, C5, C6, C7, C8, C9: 1n0 x 50V; RSMD_1206
C3, C10: 0.1uF x 50V; RSMD_1206
D1, D2: LL4148; SOD-80
J1: 0; RSMD_2512
KEY1: MODE; KEY_MTS1_NO_PINS
P1: POWER; PAD_4X4
P4: uA-; PAD_4X4
P5: SWR; PAD_4X4
R1: 750K; RSMD_1206
R2: 130K; RSMD_1206
R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R19, R20, R27, R28: 100R; RSMD_2512
R35: 4K7; RSMD_0805
R100: 330K; SP3-4AM
X1: POWER; PL-239(FEMALE)
X2: SWR_IN; PL-239(FEMALE)
X3: SWR_OUT; PL-239(FEMALE)

Connections:
GND: C1.PAD_0 (PIN0), C2.PAD_0 (PIN0), C3.PAD_0 (PIN0), C10.PAD_1 (PIN1), KEY1.GND1, KEY1.GND2, P4.PAD, R7.PAD0 (PIN0), R8.PAD0 (PIN0), R9.PAD0 (PIN0), R10.PAD0 (PIN0), R19.PAD0 (PIN0), R20.PAD0 (PIN0), R100.PACKAGE1 (PACKAGE), R100.PACKAGE2 (PACKAGE), X1.CENTER_DRILL (GND), X1.SCREW1 (GND), X1.SCREW2 (GND), X1.SCREW3 (GND), X1.SCREW4 (GND), X2.CENTER_DRILL (GND), X2.SCREW1 (GND), X2.SCREW2 (GND), X2.SCREW3 (GND), X2.SCREW4 (GND), X3.CENTER_DRILL (GND), X3.SCREW1 (GND), X3.SCREW2 (GND), X3.SCREW3 (GND), X3.SCREW4 (GND)
unnamed: J1.PAD0 (PIN0), R100.END_A
unnamed: C4.PAD_0 (PIN0), C5.PAD_0 (PIN0), D1.ANODE, R3.PAD1 (PIN1), R4.PAD1 (PIN1), R5.PAD1 (PIN1), R6.PAD1 (PIN1)
unnamed: C4.PAD_1 (PIN1), C5.PAD_1 (PIN1), X1.SIGNAL
unnamed: C6.PAD_1 (PIN1), C7.PAD_1 (PIN1), X2.SIGNAL
unnamed: C6.PAD_0 (PIN0), C7.PAD_0 (PIN0), R11.PAD1 (PIN1), R12.PAD1 (PIN1), R27.PAD1 (PIN1), R28.PAD1 (PIN1)
unnamed: P5.PAD, R100.END_B, R100.MIDDLE
unnamed: C8.PAD_1 (PIN1), C9.PAD_1 (PIN1), D2.CATHODE, R35.PAD_1 (PIN1)
unnamed: C10.PAD_0 (PIN0), J1.PAD1 (PIN1), R35.PAD_0 (PIN0)
unnamed: D2.ANODE, R11.PAD0 (PIN0), R12.PAD0 (PIN0), R19.PAD1 (PIN1), R20.PAD1 (PIN1)
unnamed: R3.PAD0 (PIN0), R4.PAD0 (PIN0), R7.PAD1 (PIN1), R8.PAD1 (PIN1)
unnamed: R5.PAD0 (PIN0), R6.PAD0 (PIN0), R9.PAD1 (PIN1), R10.PAD1 (PIN1)
unnamed: C8.PAD_0 (PIN0), C9.PAD_0 (PIN0), R27.PAD0 (PIN0), R28.PAD0 (PIN0), X3.SIGNAL
unnamed: C1.PAD_1 (PIN1), C2.PAD_1 (PIN1), D1.CATHODE, R1.PAD_1 (PIN1)
unnamed: R1.PAD_0 (PIN0), R2.PAD_1 (PIN1)
unnamed: C3.PAD_1 (PIN1), P1.PAD, R2.PAD_0 (PIN0)

Board: 2 copper layers, 86.0 x 110.0 mm, 39 parts (34 on the bottom side), 16 nets.

## EAGLE design PowerSupply_1600W/CurrentRestrictionBoard/CurrentRestrictionBoard_V1_0.brd

Parts:
C1, C4: *; RSMD_0603
C2: 0.47uF x 16V; RSMD_0805
C3: 1n0 16V; RSMD_0603
C5: 0.1uF x 16V; RSMD_0603
D1: BAT54A; SOT23_SMALL_PADS
J1: 0; RSMD_0805
R1: 22K; RSMD_0603
R2: 10R; RSMD_0805
R3: 5K1; RSMD_0603
R4, R5: *; RSMD_0603
R6: 680K; RSMD_0603
R7: 5K1; RSMD_0805
R8: 10K; RSMD_0603
U1: LM358; SOIC8
U2: TL431; SOT23
X1: GND; PIN1X1_2.5X2.5MM
X2: +12V; PIN1X1_2.5X2.5MM
X3: CS_IN; PIN1X1_2.5X2.5MM
X4: VReg_OUT; PIN1X1_2.5X2.5MM

Connections:
+12V: C2.PAD_1 (PIN1), R2.PAD_0 (PIN0), R7.PAD_1 (PIN1), U1.8 (VCC)
GND: C1.PAD_0 (PIN0), C2.PAD_0 (PIN0), C5.PAD_0 (PIN0), R8.PAD_0 (PIN0), U1.4 (GND), U2.3 (ANODE), X1.1
unnamed: R2.PAD_1 (PIN1), X2.1
unnamed: R4.PAD_1 (PIN1), X3.1
unnamed: C1.PAD_1 (PIN1), R4.PAD_0 (PIN0), U1.3 (IN+)
unnamed: C3.PAD_0 (PIN0), C4.PAD_0 (PIN0), R1.PAD_0 (PIN0), R6.PAD_1 (PIN1), R8.PAD_1 (PIN1), U1.2 (IN-)
unnamed: C3.PAD_1 (PIN1), J1.PAD_1 (PIN1), R5.PAD_0 (PIN0), R6.PAD_0 (PIN0), U1.1 (OUT)
unnamed: C4.PAD_1 (PIN1), R5.PAD_1 (PIN1)
unnamed: D1.1 (CATHODE1), D1.2 (CATHODE2), R3.PAD_1 (PIN1), U1.6 (IN-)
unnamed: D1.3 (ANODE), U1.7 (OUT)
unnamed: R3.PAD_0 (PIN0), X4.1
unnamed: C5.PAD_1 (PIN1), R1.PAD_1 (PIN1), R7.PAD_0 (PIN0), U2.1 (CATHODE), U2.2 (REFERENCE)
unnamed: J1.PAD_0 (PIN0), U1.5 (IN+)

Board: 2 copper layers, 21.5 x 15.1 mm, 21 parts (0 on the bottom side), 13 nets.

## EAGLE design HumidityMetter/schematic/HumidityMetter_v2.brd

Parts:
C1, C8, C9, C10, C11, C12, C13, C14: 0.1uF; RSMD_0603
C2, C3: 10uF x 16V; RSMD_1206
C4: 10nF x 16V; RSMD_0603
C5, C7, C17: 10uF x 10V; RSMD_1206
C6: 10uFx16V; RSMD_1206
C15: 0.1uF x 16V; RSMD_0603
C16: 4.7nF x 16V; RSMD_0603
D1: LL4148; SOD-80
D2, D11: B120; DO-214AC
D55: BAT54C; SOT23_SMALL_PADS
IC3: STM32F103C8T6; LQFP48
IC10: AMS1117-3.3; SOT223(WAVE_SOLDERING)
IC11: MP1482; SOIC8
J1, J2, J3, J4: 0; RSMD_0603
J5, J7: 0; RSMD_1206_BIG_GAP
J6: 0; RSMD_0805
K1: POWER_ON; KEY_7X4.5
L1: 39uH; COIL_7MM
L2: 20uH; RSMD_1206
LCD1: LCD_0802B; LCD_0802B_2SCREW(CHINA_CLONE)
LED1: ERROR(RED); LED_0805
R1: 1 Ohm; RSMD_1206
R2, R4, R30, R34: 10K; RSMD_0603
R3, R11, R33: 1K0; RSMD_0603
R5: 1K5; RSMD_0603
R6: 36K; RSMD_0603
R7: 8K2; RSMD_0603
R8: 100K; RSMD_0603
R12: 390R; RSMD_0805
R13, R14, R15, R21, R22, R23: 390R; RSMD_0603
R16, R17, R18, R19: 2K2; RSMD_0603
R20: 10K; R_ADJ_HOR
R24: 18K; RSMD_0603
R25: 6K8; RSMD_0603
R26, R27: 4K7; RSMD_0603
R28, R29: 200R; RSMD_0603
T1: AO3401; SOT23
T2: 2N7002; SOT23_SMALL_PADS
X1: +9V; PIN1X1_3.5MM_PWR
X2: GND; PIN1X1_3.5MM_PWR
X3: ISP; PIN4X1_2.54MM
X4: SENSOR; JST_XH2.5MM_4PIN

Connections:
+3.3V: C1.PAD_1 (PIN1), C6.PAD_1 (PIN1), C10.PAD_1 (PIN1), C11.PAD_1 (PIN1), C12.PAD_1 (PIN1), C13.PAD_1 (PIN1), D1.CATHODE, D11.CATHODE, IC3.9 (VDDA), IC3.24 (VDD1), IC3.36 (VDD2), IC3.48 (VDD3), IC10.2 (OUT), IC10.4 (OUT), J1.PAD_0 (PIN0), J3.PAD_0 (PIN0), R26.PAD_0 (PIN0), R27.PAD_0 (PIN0), R30.PAD_0 (PIN0), R34.PAD_0 (PIN0), X3.1, X4.1
+5V: C8.PAD_1 (PIN1), C17.PAD_1 (PIN1), IC10.3 (IN), L2.PAD_1 (START), LCD1.2 (VDD), LCD1.A, R20.1 (END_A)
ADC_9V: C9.PAD_1 (PIN1), D1.ANODE, IC3.12 (PA2/USART2_TX/ADC12_IN2/TIM2_CH3), R24.PAD_1 (PIN1), R25.PAD_0 (PIN0)
BOOT0: IC3.44 (BOOT0), J1.PAD_1 (PIN1), J2.PAD_0 (PIN0)
BOOT1: IC3.20 (PB2/BOOT1), J3.PAD_1 (PIN1), J4.PAD_0 (PIN0)
ERROR_LED: IC3.17 (PA7/SPI1_MOSI/ADC12_IN7/TIM3_CH2), R33.PAD_0 (PIN0)
GND: C1.PAD_0 (PIN0), C2.PAD_0 (PIN0), C3.PAD_0 (PIN0), C5.PAD_0 (PIN0), C6.PAD_0 (PIN0), C7.PAD_0 (PIN0), C8.PAD_0 (PIN0), C9.PAD_0 (PIN0), C10.PAD_0 (PIN0), C11.PAD_0 (PIN0), C12.PAD_0 (PIN0), C13.PAD_0 (PIN0), C14.PAD_0 (PIN0), C15.PAD_0 (PIN0), C17.PAD_0 (PIN0), D2.ANODE, D11.ANODE, IC3.8 (VSSA), IC3.23 (VSS1), IC3.35 (VSS2), IC3.47 (VSS3), IC10.1 (ADJ), IC11.4 (GND), J2.PAD_1 (PIN1), J4.PAD_1 (PIN1), K1.1, K1.2 (1), LCD1.1 (VSS), LCD1.K, LED1.CATHODE, R4.PAD_1 (PIN1), R5.PAD_1 (PIN1), R7.PAD_1 (PIN1), R16.PAD_1 (PIN1), R17.PAD_1 (PIN1), R18.PAD_1 (PIN1), R19.PAD_1 (PIN1), R20.3 (END_B), R25.PAD_1 (PIN1), T2.2 (SOURCE), X2.1, X3.4, X4.4
I2C_SCL: IC3.42 (PB6/I2C1_SCL/TIM4_CH1), R29.PAD_0 (PIN0)
I2C_SDA: IC3.43 (PB7/I2C1_SDA/TIM4_CH2), R28.PAD_0 (PIN0)
KEY: D55.2 (ANODE2), IC3.11 (PA1/USART2_RTS/ADC12_IN1/TIM2_CH2), R34.PAD_1 (PIN1)
LCD_D4: IC3.26 (PB13/SPI2_SCK/USART3_CTS/TIM1_CH1), R15.PAD_1 (PIN1)
LCD_D5: IC3.28 (PB15/SPI2_MOSI/TIM1_CH3N), R14.PAD_1 (PIN1)
LCD_D6: IC3.27 (PB14/SPI2_MISO/USART3_RTS/TIM1_CH2N), R13.PAD_1 (PIN1)
LCD_D7: IC3.39 (PB3/JTDO), R12.PAD_1 (PIN1)
LCD_E: IC3.25 (PB12/SPI2_NSS/I2C2_SMBAI/USART3_CK/TIM1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), R21.PAD_1 (PIN1)
LCD_R/~W: IC3.22 (PB11/I2C2_SDA/USART3_RX), R22.PAD_1 (PIN1)
LCD_RS: IC3.21 (PB10/I2C2_SCL/USART3_TX), R23.PAD_1 (PIN1)
unnamed: R1.PAD_1 (PIN1), X1.1
unnamed: D55.3 (CATHODE), K1.3 (2), K1.4 (2)
unnamed: R2.PAD_1 (PIN1), R3.PAD_0 (PIN0), T1.1 (GATE)
unnamed: J5.PAD_1 (PIN1), LCD1.3 (VO)
unnamed: R4.PAD_0 (PIN0), R11.PAD_1 (PIN1), T2.1 (GATE)
unnamed: IC3.34 (PA13/JTMS/SWDIO), J6.PAD_0 (PIN0)
unnamed: D2.CATHODE, R1.PAD_0 (PIN0), R2.PAD_0 (PIN0), T1.2 (SOURCE)
unnamed: C2.PAD_1 (PIN1), C3.PAD_1 (PIN1), IC11.2 (IN), R8.PAD_1 (PIN1), R24.PAD_0 (PIN0), T1.3 (DRAIN)
unnamed: J5.PAD_0 (PIN0), R20.2 (ADJ)
unnamed: LCD1.14 (DB7), R12.PAD_0 (PIN0)
unnamed: LCD1.13 (DB6), R13.PAD_0 (PIN0)
unnamed: LCD1.12 (DB5), R14.PAD_0 (PIN0)
unnamed: LCD1.11 (DB4), R15.PAD_0 (PIN0)
unnamed: R26.PAD_1 (PIN1), R29.PAD_1 (PIN1), X4.2
unnamed: LCD1.10 (DB3), R16.PAD_0 (PIN0)
unnamed: LCD1.9 (DB2), R17.PAD_0 (PIN0)
unnamed: LCD1.8 (DB1), R18.PAD_0 (PIN0)
unnamed: LCD1.7 (DB0), R19.PAD_0 (PIN0)
unnamed: LED1.ANODE, R33.PAD_1 (PIN1)
unnamed: R27.PAD_1 (PIN1), R28.PAD_1 (PIN1), X4.3
unnamed: LCD1.4 (RS), R23.PAD_0 (PIN0)
unnamed: LCD1.5 (R/~W), R22.PAD_0 (PIN0)
unnamed: LCD1.6 (E), R21.PAD_0 (PIN0)
unnamed: J7.PAD_1 (PIN1), R6.PAD_0 (PIN0)
unnamed: IC11.7 (EN), R8.PAD_0 (PIN0)
unnamed: D55.1 (ANODE1), R3.PAD_1 (PIN1), T2.3 (DRAIN)
unnamed: C4.PAD_0 (PIN0), IC11.3 (SW), L1.1 (START)
unnamed: C4.PAD_1 (PIN1), IC11.1 (BS)
unnamed: C5.PAD_1 (PIN1), C7.PAD_1 (PIN1), J7.PAD_0 (PIN0), L1.2 (END), L2.PAD_0 (END)
unnamed: C15.PAD_1 (PIN1), IC11.8 (SS)
unnamed: C16.PAD_1 (PIN1), IC11.6 (COMP)
unnamed: C16.PAD_0 (PIN0), R5.PAD_0 (PIN0)
unnamed: IC11.5 (FB), R6.PAD_1 (PIN1), R7.PAD_0 (PIN0)
NRST: C14.PAD_1 (PIN1), IC3.7 (NRST), R30.PAD_1 (PIN1)
PWR_HOLD: IC3.15 (PA5/SPI1_SCK/ADC12_IN5), R11.PAD_0 (PIN0)
SWDCLK: IC3.37 (PA14/JTCK/SWCLK), X3.3
SWDIO: J6.PAD_1 (PIN1), X3.2

Board: 2 copper layers, 60.2 x 58.0 mm, 72 parts (64 on the bottom side), 54 nets.

## Code that names these connections

File USBTinyISP/sw/USB_Tiny_GCC/main.c:

// ======================================================================
// USB AVR programmer and SPI interface
//
// http://www.ladyada.net/make/usbtinyisp/
//
// This code works for both v1.0 and v2.0 devices.
//
// Copyright 2006-2010 Dick Streefland
//
// This is free software, licensed under the terms of the GNU General
// Public License as published by the Free Software Foundation.
// ======================================================================

#include <avr/io.h>
#include "def.h"
#include "usb.h"

enum
{
	// Generic requests
	USBTINY_ECHO,		// echo test
	USBTINY_READ,		// read byte
	USBTINY_WRITE,		// write byte
	USBTINY_CLR,		// clear bit 
	USBTINY_SET,		// set bit
	// Programming requests
	USBTINY_POWERUP,	// apply power (wValue:SCK-period, wIndex:RESET)
	USBTINY_POWERDOWN,	// remove power from chip
	USBTINY_SPI,		// issue SPI command (wValue:c1c0, wIndex:c3c2)
	USBTINY_POLL_BYTES,	// set poll bytes for write (wValue:p1p2)
	USBTINY_FLASH_READ,	// read flash (wIndex:address)
	USBTINY_FLASH_WRITE,	// write flash (wIndex:address, wValue:timeout)
	USBTINY_EEPROM_READ,	// read eeprom (wIndex:address)
	USBTINY_EEPROM_WRITE,	// write eeprom (wIndex:address, wValue:timeout)
	USBTINY_DDRWRITE,	// set port direction
	USBTINY_SPI1		// a single SPI command
};

// ----------------------------------------------------------------------
// I/O pins:
// ----------------------------------------------------------------------
#define	PORT		PORTB
#define	DDR		DDRB
#define	PIN		PINB

#define	LED		PB0		// output
#define	RESET		PB4		// output
#define	MOSI		PB5		// output
#define	MISO		PB6		// input
#define	SCK		PB7		// output

#define	LED_MASK	_BV(LED)
#define	RESET_MASK	_BV(RESET)
#define	MOSI_MASK	_BV(MOSI)
#define	MISO_MASK	_BV(MISO)
#define	SCK_MASK	_BV(SCK)

//#define	BUFFEN		(D,4)		// output, active low

// ----------------------------------------------------------------------
// Local data
// ----------------------------------------------------------------------
static	byte_t		sck_period;	// SCK period in microseconds (1..250)
static	byte_t		poll1;		// first poll byte for write
static	byte_t		poll2;		// second poll byte for write
static	uint_t		address;	// read/write address
static	uint_t		timeout;	// write timeout in usec
static	byte_t		cmd0;		// current read/write command byte
static	byte_t		cmd[4];		// SPI command buffer
static	byte_t		res[4];		// SPI result buffer

// ----------------------------------------------------------------------
// Delay exactly <sck_period> times 0.5 microseconds (6 cycles).
// ----------------------------------------------------------------------
__attribute__((always_inline))
static	inline	void	delay ( void )
{
	asm volatile(
		"	mov	__tmp_reg__,%0	\n"
		"0:	rjmp	1f		\n"
		"1:	nop			\n"
		"	dec	__tmp_reg__	\n"
		"	brne	0b		\n"
		: : "r" (sck_period) );
}

// ----------------------------------------------------------------------
// Issue one SPI command.
// ----------------------------------------------------------------------

inline void SetSck()
{
	PORT |= SCK_MASK;
}

inline void ClearSck()
{
	PORT &= ~SCK_MASK;
}

inline void SetMosi()
{
	PORT |= MOSI_MASK;
}

inline void ClearMosi()
{
	PORT &= ~MOSI_MASK;
}

static	void	spi ( byte_t* cmd, byte_t* res, byte_t n )
{
	byte_t	c;
	byte_t	r;
	byte_t	mask;

	while	( n != 0 )
	{
		n--;
		c = *cmd++;
		r = 0;
		for	( mask = 0x80; mask; mask >>= 1 )
		{
			if	( c & mask )
			{
				SetMosi();
				//PORT |= MOSI_MASK;
			}
			delay();
			SetSck();
			//PORT |= SCK_MASK;
			delay();
			r <<= 1;
			if	( PIN & MISO_MASK )
			{
				r++;
			}
			ClearMosi();
			//PORT &= ~ MOSI_MASK;
			ClearSck();
			//PORT &= ~ SCK_MASK;
		}
		*res++ = r;
	}
}

// ----------------------------------------------------------------------
// Create and issue a read or write SPI command.
// ----------------------------------------------------------------------
static	void	spi_rw ( void )
{
	uint_t	a;

	a = address++;
	if	( cmd0 & 0x80 )
	{	// eeprom
		a <<= 1;
	}
	cmd[0] = cmd0;
	if	( a & 1 )
	{
		cmd[0] |= 0x08;
	}
	cmd[1] = a >> 9;
	cmd[2] = a >> 1;
	spi( cmd, res, 4 );
}

// ----------------------------------------------------------------------
// Handle a non-standard SETUP packet.
// ----------------------------------------------------------------------
extern	byte_t	usb_setup ( byte_t data[8] )
{
	byte_t	bit;
	byte_t	mask;
	byte_t	req;

	// Generic requests
	req = data[1];
	if	( req == USBTINY_ECHO )
	{
		return 8;
	}
	if	( req == USBTINY_READ )
	{
		data[0] = PIN;
		return 1;
	}
	if	( req == USBTINY_WRITE )
	{
		PORT = data[2];
		return 0;
	}
	bit = data[2] & 7;
	mask = 1 << bit;
	if	( req == USBTINY_CLR )
	{
		PORT &= ~ mask;
		return 0;
	}
	if	( req == USBTINY_SET )
	{
		PORT |= mask;
		return 0;
	}
	if	( req == USBTINY_DDRWRITE )
	{
		DDR = data[2];
	}

	// Programming requests
	if	( req == USBTINY_POWERUP )
	{
		sck_period = data[2];
		mask = LED_MASK;
		if	( data[4] )
		{
			mask |= RESET_MASK;
		}
//		CLR(BUFFEN);
		DDR  = LED_MASK | RESET_MASK | SCK_MASK | MOSI_MASK;
		PORT = mask;
		return 0;
	}
	if	( req == USBTINY_POWERDOWN )
	{
		DDR  = 0x00;
		PORT = 0x00;
//		SET(BUFFEN);
		return 0;
	}
	if	( ! PORT )
	{
		return 0;
	}
	if	( req == USBTINY_SPI )
	{
		spi( data + 2, data + 0, 4 );
		return 4;
	}
	if	( req == USBTINY_SPI1 )
	{
		spi( data + 2, data + 0, 1 );
		return 1;
	}
	if	( req == USBTINY_POLL_BYTES )
	{
		poll1 = data[2];
		poll2 = data[3];
		return 0;
	}
	address = * (uint_t*) & data[4];
	if	( req == USBTINY_FLASH_READ )
	{
		cmd0 = 0x20;
		return 0xff;	// usb_in() will be called to get the data
	}
	if	( req == USBTINY_EEPROM_READ )
	{
		cmd0 = 0xa0;
		return 0xff;	// usb_in() will be called to get the data
	}
	timeout = * (uint_t*) & data[2];
	if	( req == USBTINY_FLASH_WRITE )
	{
		cmd0 = 0x40;
		return 0;	// data will be received by usb_out()
	}
	if	( req == USBTINY_EEPROM_WRITE )
	{
		cmd0 = 0xc0;
		return 0;	// data will be received by usb_out()
	}
	return 0;
}

// ----------------------------------------------------------------------
// Handle an IN packet.
// ----------------------------------------------------------------------
extern	byte_t	usb_in ( byte_t* data, byte_t len )
{
	byte_t	i;

	for	( i = 0; i < len; i++ )
	{
		spi_rw();
		data[i] = res[3];
	}
	return len;
}

// ----------------------------------------------------------------------
// Handle an OUT packet.
// ----------------------------------------------------------------------
extern	void	usb_out ( byte_t* data, byte_t len )
{
	byte_t	i;
	uint_t	usec;
	byte_t	r;

	for	( i = 0; i < len; i++ )
	{
		cmd[3] = data[i];
		spi_rw();
		cmd[0] ^= 0x60;	// turn write into read
		for	( usec = 0; usec < timeout; usec += 32 * sck_period )
		{	// when timeout > 0, poll until byte is written
			spi( cmd, res, 4 );
			r = res[3];
			if	( r == cmd[3] && r != poll1 && r != poll2 )
			{
				break;
			}
		}
	}
}

// ----------------------------------------------------------------------
// Main
// ----------------------------------------------------------------------
extern	int	main ( void )
{
//	SET(BUFFEN);
//	OUTPUT(BUFFEN);
	usb_init();
	for	( ;; )
	{
		usb_poll();
	}
}

File CurrentSensor/sw/CurrentSensor/LedsControl.c:

#include "LedsControl.h"
#include "CsDelay.h"

#define LED_PORT	PORTB
#define LED_DDR		DDRB
#define LED_SCK		PB1
#define LED_DATA	PB0

inline void SetLedSck()
{
	LED_PORT |= (1 << LED_SCK);
}

inline void ClearLedSck()
{
	LED_PORT &= ~(1 << LED_SCK);
}

inline void SetLedData()
{
	LED_PORT |= (1 << LED_DATA);
}

inline void ClearLedData()
{
	LED_PORT &= ~(1 << LED_DATA);
}

inline void LedRcChainLatchDelay()
{
	DelayMicroSec(60);
}

void SendLedByte(const uint8_t byteToSend)
{
	uint8_t byte = byteToSend;

	// Clear sck and LED latch
	ClearLedSck();
	LedRcChainLatchDelay();

	for(uint8_t byteCnt = 8;; --byteCnt)
	{
		if ((byte & 0b10000000) != 0)
		{
			SetLedData();
		}
		else
		{
			ClearLedData();
		}
		
		SetLedSck();
		
		if (byteCnt == 1)
			break;		// Break on "1" sck state to activate data latch RC chain
		ClearLedSck();
		byte = byte << 1;
	}
	
	// Wait for LED latch turned ON
	LedRcChainLatchDelay();
	ClearLedSck();
}

void InitLeds()
{
	ClearLedSck();
	ClearLedData();
	LED_DDR |= (1 << LED_SCK) | (1 << LED_DATA);
	SendLedByte(0x00);	// Turn OFF all LEDs by default
}

// LEDs mapping in shift register
//  Bit:          Bit:
//   0  (R)    (G)  1
//   2  (Y)    (Y)  3
//   5  (Y)    (Y)  4
//   6  (G)    (R)  7
void UpdateLedsState(const uint8_t leftCollumn, const uint8_t rightCollumn)
{
	uint8_t ledsByte = 0x00;
	if ((leftCollumn & 0b0001) != 0)
	{
		ledsByte |= 1 << 6;
	}
	if ((leftCollumn & 0b0010) != 0)
	{
		ledsByte |= 1 << 5;
	}
	if ((leftCollumn & 0b0100) != 0)
	{
		ledsByte |= 1 << 2;
	}
	if ((leftCollumn & 0b1000) != 0)
	{
		ledsByte |= 1 << 0;
	}
	
	if ((rightCollumn & 0b0001) != 0)
	{
		ledsByte |= 1 << 7;
	}
	if ((rightCollumn & 0b0010) != 0)
	{
		ledsByte |= 1 << 4;
	}
	if ((rightCollumn & 0b0100) != 0)
	{
		ledsByte |= 1 << 3;
	}
	if ((rightCollumn & 0b1000) != 0)
	{
		ledsByte |= 1 << 1;
	}
	SendLedByte(ledsByte);
}
