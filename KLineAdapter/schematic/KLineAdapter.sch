File: KLineAdapter/schematic/KLineAdapter.sch (EAGLE design)
At the start: 25 parts, among them T1 BC847, T2 BC847, X2 OBD2_+12V, X3 USB_MICRO, X4 OBD2_KLINE, X5 OBD2_GND

Commit message: KLine adapter. Almost routed.
Parts:
- LED4: device __MyCommonLib1:LED3MM -> __MyCommonLib1:LED3MM(SMD0805)
- X2, X4, X5: device __MyCommonLib1:PIN1X13.5MM_PWR -> __MyCommonLib1:PIN1X12.54MM
Connections:
- net N$1: no longer U$2.VCC_IO
- net VCC: now also U$2.VCC_IO
Changed lines of the file:
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@@
 <part name="R13" library="__MyCommonLib1" deviceset="R" device="SMD_0805" value="1K0"/>
 <part name="R14" library="__MyCommonLib1" deviceset="R" device="SMD_0805" value="1K0"/>
-<part name="LED4" library="__MyCommonLib1" deviceset="LED3MM" device="" value="green"/>
+<part name="LED4" library="__MyCommonLib1" deviceset="LED3MM" device="(SMD0805)" value="green"/>
 <part name="D22" library="__MyCommonLib1" deviceset="LL4147" device="SOD-80" value="LL4148"/>
 <part name="C6" library="__MyCommonLib1" deviceset="C" device="SMD_0805" value="0.1uF"/>
@@
 <part name="GND18" library="supply1" deviceset="GND" device=""/>
 <part name="D4" library="__MyCommonLib1" deviceset="LL4147" device="SOD-80" value="LL4148"/>
-<part name="X4" library="__MyCommonLib1" deviceset="PIN1X1" device="3.5MM_PWR" value="OBD2_KLINE"/>
-<part name="X2" library="__MyCommonLib1" deviceset="PIN1X1" device="3.5MM_PWR" value="OBD2_+12V"/>
-<part name="X5" library="__MyCommonLib1" deviceset="PIN1X1" device="3.5MM_PWR" value="OBD2_GND"/>
+<part name="X4" library="__MyCommonLib1" deviceset="PIN1X1" device="2.54MM" value="OBD2_KLINE"/>
+<part name="X2" library="__MyCommonLib1" deviceset="PIN1X1" device="2.54MM" value="OBD2_+12V"/>
+<part name="X5" library="__MyCommonLib1" deviceset="PIN1X1" device="2.54MM" value="OBD2_GND"/>
 <part name="GND5" library="supply1" deviceset="GND" device=""/>
 </parts>
@@
 </plain>
 <instances>
-<instance part="FRAME1" gate="G$1" x="444.5" y="55.88" smashed="yes">
-<attribute name="DRAWING_NAME" x="661.67" y="71.12" size="2.54" layer="94" font="vector"/>
-<attribute name="LAST_DATE_TIME" x="661.67" y="66.04" size="2.286" layer="94" font="vector"/>
-<attribute name="SHEET" x="675.005" y="60.96" size="2.54" layer="94" font="vector"/>
+<instance part="FRAME1" gate="G$1" x="0" y="0" smashed="yes">
+<attribute name="DRAWING_NAME" x="217.17" y="15.24" size="2.54" layer="94" font="vector"/>
+<attribute name="LAST_DATE_TIME" x="217.17" y="10.16" size="2.286" layer="94" font="vector"/>
+<attribute name="SHEET" x="230.505" y="5.08" size="2.54" layer="94" font="vector"/>
 </instance>
 <instance part="X3" gate="X$1" x="15.24" y="48.26" rot="MR0"/>
@@
 <net name="N$1" class="0">
 <segment>
-<pinref part="U$2" gate="G$1" pin="VCC_IO"/>
-<wire x1="22.86" y1="111.76" x2="20.32" y2="111.76" width="0.1524" layer="91"/>
-<wire x1="20.32" y1="111.76" x2="20.32" y2="109.22" width="0.1524" layer="91"/>
 <pinref part="C1" gate="C$1" pin="PIN1"/>
-<wire x1="17.78" y1="109.22" x2="20.32" y2="109.22" width="0.1524" layer="91"/>
 <pinref part="U$2" gate="G$1" pin="3V3_OUT"/>
-<wire x1="22.86" y1="109.22" x2="20.32" y2="109.22" width="0.1524" layer="91"/>
-<junction x="20.32" y="109.22"/>
+<wire x1="22.86" y1="109.22" x2="17.78" y2="109.22" width="0.1524" layer="91"/>
 </segment>
 </net>
@@
 <segment>
 <pinref part="U$2" gate="G$1" pin="VCC"/>
-<wire x1="22.86" y1="114.3" x2="12.7" y2="114.3" width="0.1524" layer="91"/>
+<wire x1="22.86" y1="114.3" x2="20.32" y2="114.3" width="0.1524" layer="91"/>
 <label x="20.32" y="116.84" size="1.27" layer="95" font="vector" ratio="20" rot="R180"/>
-</segment>
-<segment>
+<pinref part="U$2" gate="G$1" pin="VCC_IO"/>
+<wire x1="20.32" y1="114.3" x2="12.7" y2="114.3" width="0.1524" layer="91"/>
+<wire x1="22.86" y1="111.76" x2="20.32" y2="111.76" width="0.1524" layer="91"/>
+<wire x1="20.32" y1="111.76" x2="20.32" y2="114.3" width="0.1524" layer="91"/>
+<junction x="20.32" y="114.3"/>
+</segment>
+<segment>

Commit message: KLine adapter. Almost routed.
Parts:
- L1: device __MyCommonLib1:L(0805) -> __MyCommonLib1:L
- R13: value 1K0 -> 4K7
Connections:
- removed net N$10: LED4.ANODE, R13.PIN0
- new net N$9: LED4.CATHODE, R13.PIN1
- net KLINE: now also R13.PIN0; no longer LED4.CATHODE
- net N$5: now also LED4.ANODE; no longer R13.PIN1
Other:
- moved on the sheet: LED4, R13
Changed lines of the file:
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@@
 <part name="C5" library="__MyCommonLib1" deviceset="C" device="SMD_0805" value="0.1uF"/>
 <part name="C1" library="__MyCommonLib1" deviceset="C" device="SMD_0805" value="0.1uF"/>
-<part name="L1" library="__MyCommonLib1" deviceset="L" device="(0805)" value="Bead"/>
+<part name="L1" library="__MyCommonLib1" deviceset="L" device="" value="Bead"/>
 <part name="C2" library="__MyCommonLib1" deviceset="C" device="SMD_0805" value="10nF"/>
 <part name="GND1" library="supply1" deviceset="GND" device=""/>
@@
 <part name="GND13" library="supply1" deviceset="GND" device=""/>
 <part name="GND14" library="supply1" deviceset="GND" device=""/>
-<part name="R13" library="__MyCommonLib1" deviceset="R" device="SMD_0805" value="1K0"/>
+<part name="R13" library="__MyCommonLib1" deviceset="R" device="SMD_0805" value="4K7"/>
 <part name="R14" library="__MyCommonLib1" deviceset="R" device="SMD_0805" value="1K0"/>
 <part name="LED4" library="__MyCommonLib1" deviceset="LED3MM" device="(SMD0805)" value="green"/>
@@
 <attribute name="VALUE" x="136.525" y="63.5" size="1.778" layer="96" font="vector" ratio="20"/>
 </instance>
-<instance part="R13" gate="R$1" x="137.16" y="106.68" smashed="yes" rot="MR0">
-<attribute name="NAME" x="134.62" y="106.68" size="1.27" layer="95" font="vector" ratio="20" rot="MR0"/>
-<attribute name="VALUE" x="134.62" y="104.14" size="1.27" layer="96" font="vector" ratio="20" rot="MR0"/>
+<instance part="R13" gate="R$1" x="137.16" y="99.06" smashed="yes" rot="MR0">
+<attribute name="NAME" x="134.62" y="99.06" size="1.27" layer="95" font="vector" ratio="20" rot="MR0"/>
+<attribute name="VALUE" x="134.62" y="96.52" size="1.27" layer="96" font="vector" ratio="20" rot="MR0"/>
 </instance>
 <instance part="R14" gate="R$1" x="142.24" y="106.68" smashed="yes">
@@
 <attribute name="VALUE" x="144.78" y="104.14" size="1.27" layer="96" font="vector" ratio="20"/>
 </instance>
-<instance part="LED4" gate="LED$1" x="137.16" y="96.52" smashed="yes" rot="MR180">
-<attribute name="NAME" x="135.255" y="97.79" size="1.27" layer="95" font="vector" ratio="20" rot="MR0"/>
-<attribute name="VALUE" x="135.255" y="96.52" size="1.27" layer="96" font="vector" ratio="20" rot="MR0"/>
+<instance part="LED4" gate="LED$1" x="137.16" y="109.22" smashed="yes" rot="MR180">
+<attribute name="NAME" x="135.255" y="110.49" size="1.27" layer="95" font="vector" ratio="20" rot="MR0"/>
+<attribute name="VALUE" x="135.255" y="109.22" size="1.27" layer="96" font="vector" ratio="20" rot="MR0"/>
 </instance>
 <instance part="D22" gate="D1" x="165.1" y="114.3" smashed="yes" rot="R90">
@@
 <wire x1="114.3" y1="104.14" x2="114.3" y2="114.3" width="0.1524" layer="91"/>
 <wire x1="114.3" y1="114.3" x2="137.16" y2="114.3" width="0.1524" layer="91"/>
-<pinref part="R13" gate="R$1" pin="PIN1"/>
 <wire x1="137.16" y1="114.3" x2="142.24" y2="114.3" width="0.1524" layer="91"/>
 <wire x1="142.24" y1="114.3" x2="154.94" y2="114.3" width="0.1524" layer="91"/>
 <wire x1="154.94" y1="114.3" x2="160.02" y2="114.3" width="0.1524" layer="91"/>
 <wire x1="160.02" y1="114.3" x2="162.56" y2="114.3" width="0.1524" layer="91"/>
-<wire x1="137.16" y1="111.76" x2="137.16" y2="114.3" width="0.1524" layer="91"/>
 <pinref part="R14" gate="R$1" pin="PIN1"/>
 <wire x1="142.24" y1="111.76" x2="142.24" y2="114.3" width="0.1524" layer="91"/>
-<junction x="137.16" y="114.3"/>
 <junction x="142.24" y="114.3"/>
 <pinref part="D22" gate="D1" pin="CATHODE"/>
@@
 <junction x="154.94" y="114.3"/>
 <junction x="160.02" y="114.3"/>
+<pinref part="LED4" gate="LED$1" pin="ANODE"/>
+<wire x1="137.16" y1="111.76" x2="137.16" y2="114.3" width="0.1524" layer="91"/>
+<junction x="137.16" y="114.3"/>
 </segment>
 </net>
@@
 <pinref part="T2" gate="T$1" pin="C"/>
 <wire x1="137.16" y1="91.44" x2="137.16" y2="88.9" width="0.1524" layer="91"/>
-<pinref part="LED4" gate="LED$1" pin="CATHODE"/>
-<wire x1="137.16" y1="93.98" x2="137.16" y2="91.44" width="0.1524" layer="91"/>
-<junction x="137.16" y="91.44"/>
 <wire x1="142.24" y1="91.44" x2="154.94" y2="91.44" width="0.1524" layer="91"/>
 <junction x="142.24" y="91.44"/>
@@
 <wire x1="154.94" y1="88.9" x2="154.94" y2="91.44" width="0.1524" layer="91"/>
 <junction x="154.94" y="91.44"/>
+<pinref part="R13" gate="R$1" pin="PIN0"/>
+<wire x1="137.16" y1="93.98" x2="137.16" y2="91.44" width="0.1524" layer="91"/>
+<junction x="137.16" y="91.44"/>
 </segment>
 <segment>
@@
 <wire x1="215.9" y1="101.6" x2="203.2" y2="101.6" width="0.1524" layer="91"/>
 <label x="210.82" y="104.14" size="1.27" layer="95" font="vector" ratio="20" rot="R180"/>
-</segment>
-</net>
-<net name="N$10" class="0">
-<segment>
-<pinref part="LED4" gate="LED$1" pin="ANODE"/>
-<pinref part="R13" gate="R$1" pin="PIN0"/>
-<wire x1="137.16" y1="99.06" x2="137.16" y2="101.6" width="0.1524" layer="91"/>
 </segment>
 </net>
@@
 </segment>
 </net>
+<net name="N$9" class="0">
+<segment>
+<pinref part="LED4" gate="LED$1" pin="CATHODE"/>
+<pinref part="R13" gate="R$1" pin="PIN1"/>
+<wire x1="137.16" y1="106.68" x2="137.16" y2="104.14" width="0.1524" layer="91"/>
+</segment>
+</net>

Commit message: KLine adapter. Routed.
Parts:
- added J1: 0 Ohm, __MyCommonLib1:RSMD_0805
- added LED1: red, __MyCommonLib1:LED3MM(SMD0805)
- added R5: 1K0, __MyCommonLib1:RSMD_0805
- X2, X4, X5: device __MyCommonLib1:PIN1X12.54MM -> __MyCommonLib1:PIN1X13.5MM_PWR
Connections:
- new net N$2: J1.PIN0, U$2.RXD
- new net N$6: LED1.CATHODE, R5.PIN1
- net GND: now also R5.PIN0
- net N$5: no longer R3.PIN1
- net RXD: now also J1.PIN1; no longer U$2.RXD
- net VCC: now also LED1.ANODE, R3.PIN1
Changed lines of the file:
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@@
 <part name="GND18" library="supply1" deviceset="GND" device=""/>
 <part name="D4" library="__MyCommonLib1" deviceset="LL4147" device="SOD-80" value="LL4148"/>
-<part name="X4" library="__MyCommonLib1" deviceset="PIN1X1" device="2.54MM" value="OBD2_KLINE"/>
-<part name="X2" library="__MyCommonLib1" deviceset="PIN1X1" device="2.54MM" value="OBD2_+12V"/>
-<part name="X5" library="__MyCommonLib1" deviceset="PIN1X1" device="2.54MM" value="OBD2_GND"/>
+<part name="X4" library="__MyCommonLib1" deviceset="PIN1X1" device="3.5MM_PWR" value="OBD2_KLINE"/>
+<part name="X2" library="__MyCommonLib1" deviceset="PIN1X1" device="3.5MM_PWR" value="OBD2_+12V"/>
+<part name="X5" library="__MyCommonLib1" deviceset="PIN1X1" device="3.5MM_PWR" value="OBD2_GND"/>
 <part name="GND5" library="supply1" deviceset="GND" device=""/>
+<part name="J1" library="__MyCommonLib1" deviceset="R" device="SMD_0805" value="0 Ohm"/>
+<part name="R5" library="__MyCommonLib1" deviceset="R" device="SMD_0805" value="1K0"/>
+<part name="LED1" library="__MyCommonLib1" deviceset="LED3MM" device="(SMD0805)" value="red"/>
+<part name="GND6" library="supply1" deviceset="GND" device=""/>
 </parts>
 <sheets>
@@
 <instance part="GND5" gate="1" x="213.36" y="86.36" smashed="yes">
 <attribute name="VALUE" x="212.725" y="83.82" size="1.778" layer="96" font="vector" ratio="20"/>
+</instance>
+<instance part="J1" gate="R$1" x="66.04" y="111.76" smashed="yes" rot="MR90">
+<attribute name="NAME" x="63.5" y="106.68" size="1.27" layer="95" font="vector" ratio="20" rot="MR180"/>
+<attribute name="VALUE" x="63.5" y="109.22" size="1.27" layer="96" font="vector" ratio="20" rot="MR180"/>
+</instance>
+<instance part="R5" gate="R$1" x="73.66" y="38.1" smashed="yes" rot="MR0">
+<attribute name="NAME" x="76.2" y="40.64" size="1.27" layer="95" font="vector" ratio="20" rot="MR180"/>
+<attribute name="VALUE" x="76.2" y="38.1" size="1.27" layer="96" font="vector" ratio="20" rot="MR180"/>
+</instance>
+<instance part="LED1" gate="LED$1" x="73.66" y="48.26" smashed="yes" rot="MR180">
+<attribute name="NAME" x="78.105" y="49.53" size="1.27" layer="95" font="vector" ratio="20" rot="MR180"/>
+<attribute name="VALUE" x="78.105" y="48.26" size="1.27" layer="96" font="vector" ratio="20" rot="MR180"/>
+</instance>
+<instance part="GND6" gate="1" x="73.66" y="27.94" smashed="yes">
+<attribute name="VALUE" x="73.025" y="25.4" size="1.778" layer="96" font="vector" ratio="20"/>
 </instance>
 </instances>
@@
 <pinref part="GND5" gate="1" pin="GND"/>
 </segment>
+<segment>
+<pinref part="R5" gate="R$1" pin="PIN0"/>
+<pinref part="GND6" gate="1" pin="GND"/>
+<wire x1="73.66" y1="30.48" x2="73.66" y2="33.02" width="0.1524" layer="91"/>
+</segment>
 </net>
 <net name="USB_D-" class="0">
@@
 <pinref part="L1" gate="G$1" pin="END"/>
 <wire x1="55.88" y1="53.34" x2="58.42" y2="53.34" width="0.1524" layer="91"/>
-<label x="68.58" y="55.88" size="1.27" layer="95" font="vector" ratio="20" rot="R180"/>
+<label x="83.82" y="55.88" size="1.27" layer="95" font="vector" ratio="20" rot="R180"/>
 <pinref part="C4" gate="C$1" pin="PIN1"/>
 <wire x1="58.42" y1="53.34" x2="63.5" y2="53.34" width="0.1524" layer="91"/>
-<wire x1="63.5" y1="53.34" x2="68.58" y2="53.34" width="0.1524" layer="91"/>
+<wire x1="63.5" y1="53.34" x2="73.66" y2="53.34" width="0.1524" layer="91"/>
+<wire x1="73.66" y1="53.34" x2="83.82" y2="53.34" width="0.1524" layer="91"/>
 <wire x1="58.42" y1="50.8" x2="58.42" y2="53.34" width="0.1524" layer="91"/>
 <pinref part="C5" gate="C$1" pin="PIN1"/>
@@
 <junction x="58.42" y="53.34"/>
 <junction x="63.5" y="53.34"/>
+<pinref part="LED1" gate="LED$1" pin="ANODE"/>
+<wire x1="73.66" y1="50.8" x2="73.66" y2="53.34" width="0.1524" layer="91"/>
+<junction x="73.66" y="53.34"/>
 </segment>
 <segment>
@@
 <wire x1="162.56" y1="76.2" x2="172.72" y2="76.2" width="0.1524" layer="91"/>
 <label x="172.72" y="78.74" size="1.27" layer="95" font="vector" ratio="20" rot="R180"/>
+</segment>
+<segment>
+<pinref part="R3" gate="R$1" pin="PIN1"/>
+<wire x1="114.3" y1="104.14" x2="114.3" y2="106.68" width="0.1524" layer="91"/>
+<wire x1="114.3" y1="106.68" x2="104.14" y2="106.68" width="0.1524" layer="91"/>
+<label x="109.22" y="109.22" size="1.27" layer="95" font="vector" ratio="20" rot="R180"/>
 </segment>
 </net>
@@
 <net name="N$5" class="0">
 <segment>
-<pinref part="R3" gate="R$1" pin="PIN1"/>
-<wire x1="114.3" y1="104.14" x2="114.3" y2="114.3" width="0.1524" layer="91"/>
-<wire x1="114.3" y1="114.3" x2="137.16" y2="114.3" width="0.1524" layer="91"/>
 <wire x1="137.16" y1="114.3" x2="142.24" y2="114.3" width="0.1524" layer="91"/>
 <wire x1="142.24" y1="114.3" x2="154.94" y2="114.3" width="0.1524" layer="91"/>
@@
 <pinref part="LED4" gate="LED$1" pin="ANODE"/>
 <wire x1="137.16" y1="111.76" x2="137.16" y2="114.3" width="0.1524" layer="91"/>
-<junction x="137.16" y="114.3"/>
 </segment>
 </net>
@@
 <net name="RXD" class="0">
 <segment>
-<pinref part="U$2" gate="G$1" pin="RXD"/>
-<wire x1="58.42" y1="111.76" x2="68.58" y2="111.76" width="0.1524" layer="91"/>
-<label x="63.5" y="111.76" size="1.27" layer="95" font="vector" ratio="20"/>
+<wire x1="71.12" y1="111.76" x2="81.28" y2="111.76" width="0.1524" layer="91"/>
+<label x="76.2" y="111.76" size="1.27" layer="95" font="vector" ratio="20"/>
+<pinref part="J1" gate="R$1" pin="PIN1"/>
 </segment>
 <segment>
@@
 </segment>
 </net>
+<net name="N$2" class="0">
+<segment>
+<pinref part="U$2" gate="G$1" pin="RXD"/>
+<pinref part="J1" gate="R$1" pin="PIN0"/>
+<wire x1="60.96" y1="111.76" x2="58.42" y2="111.76" width="0.1524" layer="91"/>
+</segment>
+</net>
+<net name="N$6" class="0">
+<segment>
+<pinref part="LED1" gate="LED$1" pin="CATHODE"/>
+<pinref part="R5" gate="R$1" pin="PIN1"/>
+<wire x1="73.66" y1="45.72" x2="73.66" y2="43.18" width="0.1524" layer="91"/>
+</segment>
+</net>
