File: L_Saturation_Meter/schematic/L_SaturationMeter.sch (EAGLE design)
At the start: 38 parts, among them IC1 LM317, IC4 LM358, T1 IRF830, T2 BC847, T3 BC857, X2 POWER_12V, X3 L_TEST, X4 I_SENSE

Commit message: Fix inconsistancy error
Parts:
- removed C12: 470uFx16V, __MyCommonLib1:CE10MM
- added C100, C8: 1000uFx25V, __MyCommonLib1:CE10MM
- added C104: 470uFx16V, __MyCommonLib1:CE8.2MM
Connections:
- net GND: now also C100.-, C8.-
- net N$6: now also C104.-; no longer C12.+
- net N$9: now also C100.+, C104.+, C8.+; no longer C12.-

Commit message: Fix CE packages pads naming, to avoid inconsistance after package change
Parts:
- C2: device __MyCommonLib1:CE10MM -> __MyCommonLib1:CE8.2MM
- C4: device __MyCommonLib1:CE6.3MM -> __MyCommonLib1:CE5.2MM
Connections:
- net +VCC: now also C4.PLUS; no longer C4.+
- net GND: now also C100.MINUS, C2.MINUS, C4.MINUS, C8.MINUS; no longer C100.-, C2.-, C4.-, C8.-
- net N$11: now also C2.PLUS; no longer C2.+
- net N$6: now also C104.MINUS; no longer C104.-
- net N$9: now also C100.PLUS, C104.PLUS, C8.PLUS; no longer C100.+, C104.+, C8.+

Commit message: Start routing
Parts:
- added X1: (no value), con-wago-500:W237-102
- D5: device __MyCommonLib1:1N4001DO-41_10MM -> __MyCommonLib1:1N4001DO-41_5MM
- R12: device __MyCommonLib1:R2.0W -> __MyCommonLib1:R1.0W_VERT
- R14: device __MyCommonLib1:R1.0W -> __MyCommonLib1:R1.0W_VERT
- X3: value L_TEST -> (none)
Connections:
- net N$10: now also X3-1.KL
- net N$9: now also X1-1.KL, X1-2.KL; no longer X3-1.KL
Other:
- note added: "L_TEST"
- moved on the sheet: C100, C104, C13, C14, C8, D100, D5, R13, R14, X2-1, X2-2, X3-1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

Commit message: L saturation metter routed
Parts:
- X1: value (none) -> L_TEST_START
- X3: value (none) -> L_TEST_END
Changed lines of the file:
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@@
 <part name="R13" library="__MyCommonLib1" deviceset="R" device="2.0W" value="10R"/>
 <part name="X2" library="con-wago-500" deviceset="W237-102" device="" value="POWER_12V"/>
-<part name="X3" library="con-wago-500" deviceset="W237-102" device=""/>
+<part name="X3" library="con-wago-500" deviceset="W237-102" device="" value="L_TEST_END"/>
 <part name="X4" library="con-wago-500" deviceset="W237-102" device="" value="I_SENSE"/>
 <part name="GND4" library="supply1" deviceset="GND" device=""/>
@@
 <part name="C8" library="__MyCommonLib1" deviceset="CE" device="10MM" value="1000uFx25V"/>
 <part name="C104" library="__MyCommonLib1" deviceset="CE" device="8.2MM" value="470uFx16V"/>
-<part name="X1" library="con-wago-500" deviceset="W237-102" device="">
+<part name="X1" library="con-wago-500" deviceset="W237-102" device="" value="L_TEST_START">
 <attribute name="MF" value=""/>
 <attribute name="MPN" value="237-102"/>
@@
 </instance>
 <instance part="X3" gate="-2" x="200.66" y="129.54" smashed="yes" rot="MR0">
-<attribute name="VALUE" x="203.2" y="126.873" size="1.778" layer="96" rot="MR180"/>
 <attribute name="NAME" x="200.66" y="130.429" size="1.778" layer="95" rot="MR180"/>
 </instance>
@@
 <attribute name="NAME" x="200.66" y="150.749" size="1.778" layer="95" rot="MR180"/>
 </instance>
-<instance part="X1" gate="-2" x="200.66" y="144.78" rot="MR0"/>
+<instance part="X1" gate="-2" x="200.66" y="144.78" smashed="yes" rot="MR0">
+<attribute name="NAME" x="200.66" y="145.669" size="1.778" layer="95" rot="MR180"/>
+</instance>
 </instances>
 <busses>

Commit message: L saturation meter. Ver2 schematic complete
Parts:
- added C11: 1n0, __MyCommonLib1:CSMD_0805
- added C12: 10nF, __MyCommonLib1:CSMD_0805
- added C15, C9: 0.1uF, __MyCommonLib1:CSMD_0805
- added D10, D11, D12, D6, D7, D8, D9: LL4148, __MyCommonLib1:LL4147SOD-80
- added D101: BAT54C, __MyCommonLib1:BAT54C(SOT23)
- added D13: FR207, __MyCommonLib1:1N4001DO-41_10MM
- added R10: 1K0, __MyCommonLib1:RSMD_0805
- added R15, R16, R17, R18: 10K, __MyCommonLib1:RSMD_0805
- added R19: 510R, __MyCommonLib1:RSMD_0805
- added R20: 100K, __MyCommonLib1:R_ADJ_WITH_SHIELDSP4-AM
- added R21, R22: 330R, __MyCommonLib1:RSMD_0805
- added R23: 1K, __MyCommonLib1:RSMD_0805
- added R24: 330R, __MyCommonLib1:RSMD_1206_BIG_GAP
- added R25, R26: 510R, __MyCommonLib1:RSMD_1206_BIG_GAP
- added R27: 20R, __MyCommonLib1:RSMD_1206_BIG_GAP
- added R28, R29: 20R, __MyCommonLib1:RSMD_0805
- added R30: 10R, __MyCommonLib1:R0.5W
- added R31: 0.01R, __MyCommonLib1:RSMD_2512
- added R9: 10K, __MyCommonLib1:R_ADJ_WITH_SHIELDSP4-AM
- added SW1: DUR_10X, __MyCommonLib1:SWITCH_DOUBLE(2.54X4MM)
- added T4, T5: BC847, __MyCommonLib1:BC847SOT23_SMALL_PADS
- added T6, T7: IRF830, __MyCommonLib1:IRF830TO-220_HORIZONTAL
- added X5: Synchro, con-wago-500:W237-102
- added X6: L_TEST_END, con-wago-500:W237-102
- C10: value 1n0 -> 0.1uFx25V
- C7: value 1n0 -> 47uFx16V; device __MyCommonLib1:CSMD_0805 -> __MyCommonLib1:CE5.2MM
- R13: value 10R -> 1R0
- R6: value 100K -> 1K0
- R8: value 10K -> 2K
- T3: value BC857 -> BC847; device __MyCommonLib1:BC857SOT23_SMALL_PADS -> __MyCommonLib1:BC847SOT23_SMALL_PADS
- X1: value L_TEST_START -> I_SENSE_100x
- X4: value I_SENSE -> I_SENSE_10x
Connections:
- removed net N$9: C100.PLUS, C104.PLUS, C13.PIN0, C14.PIN0, C8.PLUS, R13.PIN1, R14.PIN1, X1-1.KL, X1-2.KL
- new net +12V_FILTERED: C100.PLUS, C104.MINUS, C13.PIN0, C14.PIN0, C8.PLUS, R13.PIN1, R14.PIN1, R30.PIN1, X3-2.KL, X6-2.KL
- new net N$12: IC4G$2.IN+, R15.PIN1, R16.PIN0, R17.PIN1
- new net N$19: R18.PIN0, T4.B
- new net N$20: R19.PIN0, T4.E, X5-1.KL
- new net N$21: D6.CATHODE, R21.PIN0, R22.PIN1
- new net N$22: C12.PIN0, SW1.POS_A1, SW1.POS_A2
- new net N$23: IC4G$1.OUT, R20.END_A, R20.MIDDLE, R23.PIN1, R5.PIN0
- new net N$24: R23.PIN0, T5.B
- new net N$25: R24.PIN0, R8.PIN0, T5.E
- new net N$26: D101.ANODE2, R8.PIN1, T3.B
- new net N$27: D101.CATHODE, D7.CATHODE, D8.CATHODE, T3.C
- new net N$28: D11.CATHODE, D9.ANODE, R28.PIN1, T7.GATE
- new net N$29: R27.PIN1, T2.C
- new net N$30: D8.ANODE, R11.PIN0, R28.PIN0, R29.PIN0, T2.E
- new net N$31: D10.ANODE, D12.CATHODE, R29.PIN1, T1.GATE
- new net N$32: R31.PIN1, T6.SOURCE, T7.SOURCE, X1-1.KL
- new net N$33: C10.PIN0, C7.PLUS, D10.CATHODE, D2.CATHODE, D9.CATHODE, R26.PIN0, R27.PIN0, R30.PIN0
- new net N$34: D13.ANODE, T6.DRAIN, T7.DRAIN, X6-1.KL
- new net N$4: C9.PIN0, IC4G$2.IN-, R10.PIN0
- new net N$5: R10.PIN1, R9.END_A
- net +VCC: now also C15.PIN0, R16.PIN1, R21.PIN1, R6.PIN0, T4.C, T5.C; no longer D2.CATHODE, T2.C
- net GND: now also C10.PIN1, C12.PIN1, C15.PIN1, C7.MINUS, C9.PIN1, D11.ANODE, D12.ANODE, R15.PIN0, R19.PIN1, R20.PACKAGE, R22.PIN0, R24.PIN1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; no longer IC4G$2.IN+, T3.C
- net N$1: now also D7.ANODE, R25.PIN1, T2.B; no longer C10.PIN1, R11.PIN0, T2.E, T3.E
- net N$10: no longer X3-2.KL
- net N$13: now also C11.PIN1, R17.PIN0, R18.PIN1, R9.END_B, R9.MIDDLE; no longer IC4G$2.IN-
- net N$14: now also D4.ANODE
- net N$15: now also R20.END_B; no longer C7.PIN1, IC4G$1.OUT, R5.PIN0, R6.PIN0, R8.PIN0
- net N$16: now also R25.PIN0, R26.PIN1; no longer C7.PIN0, R8.PIN1, T2.B, T3.B
- net N$18: now also C11.PIN0, D4.CATHODE, R6.PIN1; no longer D4.ANODE, R7.PIN1
- net N$2: now also T6.GATE; no longer C10.PIN0, T1.GATE
- net N$6: now also C104.PLUS, D13.CATHODE; no longer C104.MINUS
- net N$7: now also D6.ANODE, R7.PIN1, SW1.CENTER1, SW1.CENTER2; no longer D4.CATHODE, R6.PIN1
Other:
- note added: "Frequency"
- note added: "L_TEST_100X"
- note added: "L_TEST_10X"
- note added: "duration"
- note added: "fine"
- note added: "rough"
- note removed: "L_TEST"
- moved on the sheet: C10, C104, C13, C6, D1, D100, D2, D4, IC4G$1, IC4G$2, R102, R11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

Commit message: L saturation meter. Parts locating
Parts:
- added C16, C17: 1000uFx25V, __MyCommonLib1:CE10MM
- T1, T6, T7: device __MyCommonLib1:IRF830TO-220_HORIZONTAL -> __MyCommonLib1:IRF830TO-200(HORIZONTAL_SCREW_PAD)
Connections:
- net +12V_FILTERED: now also C16.PLUS, C17.PLUS, X6-1.KL; no longer R30.PIN1, X6-2.KL
- net GND: now also C16.MINUS, C17.MINUS, R12.PIN1, X1-1.KL, X2-1.KL, X4-1.KL; no longer R12.PIN0, X1-2.KL, X2-2.KL, X4-2.KL
- net N$11: now also R30.PIN1, X2-2.KL; no longer X2-1.KL
- net N$3: now also R12.PIN0, X4-2.KL; no longer R12.PIN1, X4-1.KL
- net N$32: now also X1-2.KL; no longer X1-1.KL
- net N$34: now also X6-2.KL; no longer X6-1.KL
Other:
- moved on the sheet: C14, R12, X1-1, X1-2, X2-1, X2-2, X4-1, X4-2, X6-1, X6-2

Commit message: L saturation meter. Routing step 1
Parts:
- removed C17: 1000uFx25V, __MyCommonLib1:CE10MM
- removed D1, D10, D11, D12, D9: LL4148, __MyCommonLib1:LL4147SOD-80
- added D14: LL4148, __MyCommonLib1:LL4147SOD-80
- D100: device __MyCommonLib1:1N4001DO-41_10MM -> __MyCommonLib1:1N4001DO-41_20MM
- D13: device __MyCommonLib1:1N4001DO-41_10MM -> __MyCommonLib1:1N4001DO-41_5MM
- D3: device __MyCommonLib1:1N4001DO-41_10MM -> __MyCommonLib1:1N4001DO-41_15MM
- D5: device __MyCommonLib1:1N4001DO-41_5MM -> __MyCommonLib1:1N4001DO-41_15MM
- R19, R23: device __MyCommonLib1:RSMD_0805 -> __MyCommonLib1:RSMD_1206_BIG_GAP
- T1, T6, T7: device __MyCommonLib1:IRF830TO-200(HORIZONTAL_SCREW_PAD) -> __MyCommonLib1:IRF830D2PAK
Connections:
- removed net N$17: R102.END_B, R7.PIN0
- new net N$35: R20.END_A, R7.PIN0
- net +12V_FILTERED: no longer C17.PLUS
- net GND: now also D14.ANODE, X1-2.KL, X4-2.KL; no longer C17.MINUS, D1.ANODE, D11.ANODE, D12.ANODE, X1-1.KL, X4-1.KL
- net N$15: now also R20.MIDDLE; no longer R102.MIDDLE
- net N$2: no longer D1.CATHODE, D2.ANODE
- net N$23: now also R102.END_B, R102.MIDDLE; no longer R20.END_A, R20.MIDDLE
- net N$28: no longer D11.CATHODE, D9.ANODE
- net N$3: now also X4-1.KL; no longer X4-2.KL
- net N$30: now also D14.CATHODE, D2.ANODE
- net N$31: no longer D10.ANODE, D12.CATHODE
- net N$32: now also X1-1.KL; no longer X1-2.KL
- net N$33: no longer D10.CATHODE, D9.CATHODE
Other:
- moved on the sheet: D2, R102, R20, X1-1, X1-2, X4-1, X4-2
