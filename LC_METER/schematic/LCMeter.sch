File: LC_METER/schematic/LCMeter.sch (EAGLE design)
At the start: 50 parts, among them J10 0, Q1 12MHz, SW4 SWITCH_DOUBLE(2.54X4MM), T6 BC847, X1 USB_B, X2 Target_MCU, X3 USB_MICRO

Commit message: LMeter new changes
Parts:
- removed C16: 0.1uF, __MyCommonLib1:CSMD_0805
- added C10, C11, C4, C7, C9: 0.1uF, __MyCommonLib1:CSMD_0805
- added C5: 4.7uF, __MyCommonLib1:CSMD_1206
- added D11, D12, D4, D7, D8, D9: LL4148, __MyCommonLib1:LL4147SOD-80
- added IC1, IC2, IC3, IC4, IC5: 74HC595, __MyCommonLib1:74HC595(SOIC16)
- added J1: 0, __MyCommonLib1:RSMD_0805
- added J123, J2, J3, J4, J5, J6, J7, J8, J9: 0, __MyCommonLib1:RSMD_1206_BIG_GAP
- added R13: 1K0, __MyCommonLib1:RSMD_0805
- added R14, R15: 4K7, __MyCommonLib1:RSMD_0805
- added R16: 100R, __MyCommonLib1:RSMD_0805
- added R19, R20, R21, R22, R23, R24, R25, R26, R28, R30, R32, R35, R36, R37, R38, R39, R40, R41, R42, R43, R44, R45, R46, R47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: 560R, __MyCommonLib1:RSMD_0805
- added R59, R60, R61: 300R, __MyCommonLib1:RSMD_0805
- added R9: 68R, __MyCommonLib1:RSMD_0805
- C8: value 4.7uF -> 0.1uF; device __MyCommonLib1:CSMD_1206 -> __MyCommonLib1:CSMD_0805
- D1: value 1N4001 -> LL4148; device __MyCommonLib1:1N4001DO-41_10MM -> __MyCommonLib1:LL4147SOD-80
- D2: value LL4148 -> 1N4001; device __MyCommonLib1:LL4147SOD-80 -> __MyCommonLib1:1N4001DO-41_10MM
- J10: device __MyCommonLib1:RSMD_0805 -> __MyCommonLib1:RSMD_1206_BIG_GAP
- LED1: value green -> Target_Power
- LED3: value Target_Power -> green
- LI1, LI2, LI3, LI4, LI5: device __MyCommonLib1:KEM5161(KEM5161) -> __MyCommonLib1:KEM5161(NARROW)
- R1: value 1K5 -> 4K7; device __MyCommonLib1:RSMD_0805 -> __MyCommonLib1:RSMD_1206
- R10: value 1K0 -> 1K5
- R11: value 4K7 -> 1K0
- R17: value 1K0 -> 1K
- R18: value 100R -> 1K
- R2: value 68R -> 1K0
- R27, R29, R31: value 1K0 -> 560R
- R3: value 68R -> 10R; device __MyCommonLib1:RSMD_0805 -> __MyCommonLib1:R0207
- R33: value 10R -> 560R; device __MyCommonLib1:R0207 -> __MyCommonLib1:RSMD_0805
- R34: value 100R -> 560R
- R4: value 4K7 -> 100R; device __MyCommonLib1:RSMD_1206 -> __MyCommonLib1:RSMD_0805
- R5, R6: value 1K -> 1K0
- R8: value 4K7 -> 68R
- X1: value USB_B -> Target_MCU; device __MyCommonLib1:USB_TYPE_B(TYPE_B_SMALL_PADS) -> __MyCommonLib1:PIN2X5_FEMALE2.54MM_RIGHT_ANGLE_SMALL_PADS
- X2: value Target_MCU -> USB_MICRO; device __MyCommonLib1:PIN2X5_FEMALE2.54MM_RIGHT_ANGLE_SMALL_PADS -> __MyCommonLib1:USB_MICROMICRO
- X3: value USB_MICRO -> USB_B; device __MyCommonLib1:USB_MICROMICRO -> __MyCommonLib1:USB_TYPE_B(TYPE_B_SMALL_PADS)
- ZD1: value 3V6 -> 5.6V
- ZD3: value 5.6V -> 3V6
- renumbered DD4 to DD1, DD5 to DD2, DD6 to DD3, SW4 to SW1, T6 to T1
Connections:
- new net LED_DATA: R59.PIN0
- new net LED_DATA': D12.ANODE, D9.CATHODE, IC1.SER_IN, R59.PIN1
- new net LED_LATCH: R61.PIN0
- new net LED_LATCH': D10.ANODE, D7.CATHODE, J10.PIN0, J2.PIN0, J4.PIN0, J6.PIN0, J8.PIN0, R61.PIN1
- new net LED_SCK: R60.PIN0
- new net LED_SCK': D11.ANODE, D8.CATHODE, J123.PIN0, J3.PIN0, J5.PIN0, J7.PIN0, J9.PIN0, R60.PIN1
- new net N$100: IC1.SER_CLK, J123.PIN1
- new net N$101: IC1.LATCH, J2.PIN1
- new net N$102: IC2.SER_CLK, J3.PIN1
- new net N$103: IC2.LATCH, J4.PIN1
- new net N$104: IC5.SER_CLK, J9.PIN1
- new net N$105: IC4.SER_CLK, J7.PIN1
- new net N$106: IC3.SER_CLK, J5.PIN1
- new net N$107: IC5.LATCH, J10.PIN1
- new net N$108: IC4.LATCH, J8.PIN1
- new net N$109: IC3.LATCH, J6.PIN1
- new net N$15: IC2.QB, R28.PIN0
- new net N$16: IC2.QC, R29.PIN0
- new net N$17: IC2.QD, R30.PIN0
- new net N$18: IC2.QE, R31.PIN0
- new net N$19: LI1.E, R19.PIN1
- new net N$20: LI1.D, R21.PIN1
- new net N$21: LI1.C, R24.PIN1
- new net N$22: IC2.QF, R32.PIN0
- new net N$23: LI1.DOT, R26.PIN1
- new net N$24: LI1.G, R20.PIN1
- new net N$26: IC2.QG, R33.PIN0
- new net N$27: LI1.F, R22.PIN1
- new net N$28: LI1.A, R23.PIN1
- new net N$29: LI1.B, R25.PIN1
- new net N$30: IC1.QA, R19.PIN0
- new net N$31: IC1.QB, R20.PIN0
- new net N$32: IC1.QC, R21.PIN0
- new net N$33: IC1.QD, R22.PIN0
- new net N$34: IC1.QE, R23.PIN0
- new net N$35: IC1.QF, R24.PIN0
- new net N$36: IC1.QG, R25.PIN0
- new net N$37: IC1.QH, R26.PIN0
- new net N$38: IC2.QH, R34.PIN0
- new net N$40: LI2.E, R27.PIN1
- new net N$41: LI2.D, R29.PIN1
- new net N$42: LI2.C, R32.PIN1
- new net N$43: LI2.DOT, R34.PIN1
- new net N$44: LI2.G, R28.PIN1
- new net N$45: LI2.F, R30.PIN1
- new net N$46: LI2.A, R31.PIN1
- new net N$47: LI2.B, R33.PIN1
- new net N$48: IC3.QA, R35.PIN0
- new net N$49: IC3.QB, R36.PIN0
- new net N$50: IC3.QC, R37.PIN0
- new net N$51: IC3.QD, R38.PIN0
- new net N$52: IC3.QE, R39.PIN0
- new net N$53: IC3.QF, R40.PIN0
- new net N$54: IC3.QG, R41.PIN0
- new net N$55: IC3.QH, R42.PIN0
- new net N$56: LI3.E, R35.PIN1
- new net N$57: LI3.D, R37.PIN1
- new net N$58: LI3.C, R40.PIN1
- new net N$59: LI3.DOT, R42.PIN1
- new net N$60: LI3.G, R36.PIN1
- new net N$61: LI3.F, R38.PIN1
- new net N$62: LI3.A, R39.PIN1
- new net N$63: LI3.B, R41.PIN1
- new net N$64: IC4.QA, R43.PIN0
- new net N$65: IC4.QB, R44.PIN0
- new net N$66: IC4.QC, R45.PIN0
- new net N$67: IC4.QD, R46.PIN0
- new net N$68: IC4.QE, R47.PIN0
- new net N$69: IC4.QF, R48.PIN0
- new net N$70: IC4.QG, R49.PIN0
- new net N$71: IC4.QH, R50.PIN0
- new net N$72: LI4.E, R43.PIN1
- new net N$73: LI4.D, R45.PIN1
- new net N$74: LI4.C, R48.PIN1
- new net N$75: LI4.DOT, R50.PIN1
- new net N$76: LI4.G, R44.PIN1
- new net N$77: LI4.F, R46.PIN1
- new net N$78: LI4.A, R47.PIN1
- new net N$79: LI4.B, R49.PIN1
- new net N$80: IC5.QA, R51.PIN0
- new net N$81: IC5.QB, R52.PIN0
- new net N$82: IC5.QC, R53.PIN0
- new net N$83: IC5.QD, R54.PIN0
- new net N$84: IC5.QE, R55.PIN0
- new net N$85: IC5.QF, R56.PIN0
- new net N$86: IC5.QG, R57.PIN0
- new net N$87: IC5.QH, R58.PIN0
- new net N$88: LI5.E, R51.PIN1
- new net N$89: LI5.D, R53.PIN1
- new net N$90: LI5.C, R56.PIN1
- new net N$91: LI5.DOT, R58.PIN1
- new net N$92: LI5.G, R52.PIN1
- new net N$93: LI5.F, R54.PIN1
- new net N$94: LI5.A, R55.PIN1
- new net N$95: LI5.B, R57.PIN1
- new net N$96: IC3.SER_OUT, IC4.SER_IN
- new net N$97: IC2.SER_OUT, IC3.SER_IN
- new net N$98: IC1.SER_OUT, IC2.SER_IN
- new net N$99: IC4.SER_OUT, IC5.SER_IN
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
Commit message: LCMeter next changes
Parts:
- removed DD1, DD2, DD3: BAT54C, __MyCommonLib1:BAT54C(SOT23)
- removed J1: 0, __MyCommonLib1:RSMD_0805
- removed LED1: Target_Power, __MyCommonLib1:LED3MM
- removed LED2: red, __MyCommonLib1:LED3MM
- removed LED3: green, __MyCommonLib1:LED3MM
- removed Q1: 12MHz, crystal:CRYSTALHC49U-V
- removed SW1: SWITCH_DOUBLE(2.54X4MM), __MyCommonLib1:SWITCH_DOUBLE(2.54X4MM)
- removed U$1: ATTINY2313SOIC20, __MyCommonLib1:ATTINY2313SOIC20
- removed X2: USB_MICRO, __MyCommonLib1:USB_MICROMICRO
- removed X3: USB_B, __MyCommonLib1:USB_TYPE_B(TYPE_B_SMALL_PADS)
- removed ZD2, ZD3: 3V6, __MyCommonLib1:ZENNER(SOD_80)
- added C12, C13: 22pF, __MyCommonLib1:CSMD_0805
- added C14, C15, C16, C17, C19, C23, C24, C25, C26, C27, C29, C30, C32, C33, C34, C35, C36, C37, C38, C39: 0.1uF, __MyCommonLib1:CSMD_0805
- added C18: 4.7uF, __MyCommonLib1:CE6.3MM
- added C20: 1nF, __MyCommonLib1:CSMD_0805
- added C21: 22nF*, __MyCommonLib1:CSMD_0805
- added C22: 1.0uF, __MyCommonLib1:CSMD_1206_BIG_GAP
- added D13, D14, D15, D16, D5, D6: LL4148, __MyCommonLib1:LL4147SOD-80
- added IC6: MEGA8535, atmel:MEGA8535-A
- added J11: 0, __MyCommonLib1:RSMD_0805
- added Q2: 12MHz, crystal:CRYSTALHC49U-V
- added R154, R63, R68, R72, R73: 100R, __MyCommonLib1:RSMD_1206_BIG_GAP
- added R62: 4K7, __MyCommonLib1:RSMD_0805
- added R64: 25K, __MyCommonLib1:RSMD_1206_BIG_GAP
- added R65: 1K5, __MyCommonLib1:RSMD_0805
- added R66: 100K, __MyCommonLib1:RSMD_1206_BIG_GAP
- added R67, R69, R70, R71: 1K0, __MyCommonLib1:RSMD_1206_BIG_GAP
- added T2, T5, T6, T7: BC847, __MyCommonLib1:BC847SOT23_SMALL_PADS
- added T3, T4: BC857, __MyCommonLib1:BC857SOT23_SMALL_PADS
- added U15: LM324, __MyCommonLib1:LM324
- added X4: L_X, con-wago-500:W237-102
- added X5: USB_B, __MyCommonLib1:USB_TYPE_B(TYPE_B_SMALL_PADS)
- added X6: USB_MICRO, __MyCommonLib1:USB_MICROMICRO
- added ZD4: 3V6, __MyCommonLib1:ZENNER(SOD_80)
- C1, C2: value 22pF -> 0.1uF
- C3: value 4.7uF -> 0.1uF; device __MyCommonLib1:CSMD_1206 -> __MyCommonLib1:CSMD_0805
- C4: value 0.1uF -> 1nF
- C5: value 4.7uF -> 0.47uF; device __MyCommonLib1:CSMD_1206 -> __MyCommonLib1:CSMD_1206_BIG_GAP
- D2: value 1N4001 -> LL4148; device __MyCommonLib1:1N4001DO-41_10MM -> __MyCommonLib1:LL4147SOD-80
- R1: value 4K7 -> 100K; device __MyCommonLib1:RSMD_1206 -> __MyCommonLib1:RSMD_0805
- R10: value 1K5 -> 20K
- R11: value 1K0 -> 100K; device __MyCommonLib1:RSMD_0805 -> __MyCommonLib1:RSMD_1206_BIG_GAP
- R12, R16: value 100R -> 1K0; device __MyCommonLib1:RSMD_0805 -> __MyCommonLib1:RSMD_1206_BIG_GAP
- R13: value 1K0 -> 100R; device __MyCommonLib1:RSMD_0805 -> __MyCommonLib1:RSMD_1206_BIG_GAP
- R14: value 4K7 -> 25K; device __MyCommonLib1:RSMD_0805 -> __MyCommonLib1:RSMD_1206_BIG_GAP
- R15: value 4K7 -> 100K; device __MyCommonLib1:RSMD_0805 -> __MyCommonLib1:RSMD_1206_BIG_GAP
- R17, R18: value 1K -> 68R
- R2: value 1K0 -> 300R
- R3: value 10R -> 4K7; device __MyCommonLib1:R0207 -> __MyCommonLib1:RSMD_0805
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Connections:
- removed net LED1: R18.PIN0, U$1.PB0(AIN0/PCINT0)
- removed net LED2: R17.PIN0, U$1.PD5(OC0B/T1)
- removed net N$10: J1.PIN1, X2.D-
- removed net RST: R1.PIN1, U$1.PA2(~RESET/DW)
- removed net SPI_MISO: DD1.ANODE2, R13.PIN1, T1.C, U$1.PB5(MOSI/DI/SDA/PCINT5)
- removed net SPI_MOSI: D1.CATHODE, DD2.ANODE2, U$1.PB6(MISO/DO/PCINT6)
- removed net SPI_RST: D3.CATHODE, DD1.ANODE1, U$1.PB4(OC1B/PCINT4)
- removed net SPI_SCK: D4.CATHODE, DD2.ANODE1, U$1.PB7(USCK/SCL/PCINT7)
- removed net T_MISO: R16.PIN1, X1.3
- removed net T_MOSI: R4.PIN1, X1.9
- removed net T_RST: R7.PIN1, X1.6
- removed net T_SCK: R12.PIN1, X1.1
- removed net T_VCC: C5.PIN1, C6.PIN1, D2.CATHODE, DD3.CATHODE, R11.PIN0, R14.PIN1, R15.PIN1, R2.PIN0, R3.PIN0, R5.PIN0, R6.PIN0, SW1.POS_B1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
- new net +5V_FINE: C14.PIN1, C15.PIN1, C16.PIN1, C17.PIN1, C18.+, C19.PIN1, C2.PIN1, IC6.AVCC, IC6.VCC, IC6.VCC1, IC6.VCC2, R154.PIN0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
- new net -5V_FINE: C1.PIN0, U15PWR.GND
- new net ESR_ADC: C33.PIN1, R69.PIN1
- new net ESR_ADC_100X: C39.PIN1, R71.PIN1
- new net ESR_ADC_10X: C36.PIN1, R70.PIN1
- new net ESR_PWM: C20.PIN1, R3.PIN0
- new net L_ADC: C3.PIN0, D2.CATHODE, R2.PIN1
- new net L_PWM: C4.PIN1, R6.PIN0
- new net MCU_RST: IC6.RESET, R62.PIN1
- new net N$110: C13.PIN1, IC6.XTAL1, Q2.2
- new net N$111: C12.PIN1, IC6.XTAL2, Q2.1
- new net N$112: IC6.(INT0)PD2, R65.PIN1
- new net N$113: C21.PIN1, C22.PIN1, R4.PIN1
- new net N$114: C22.PIN0, C23.PIN1, D3.CATHODE, D4.ANODE, X1-1.KL
- new net N$115: C23.PIN0, R11.PIN0, R5.PIN1, T5.B
- new net N$116: C25.PIN1, C26.PIN1, R12.PIN0, T5.C
- new net N$117: R13.PIN1, T5.E
- new net N$118: C26.PIN0, R14.PIN1, R15.PIN0, T6.B
- new net N$119: C29.PIN1, C34.PIN1, R16.PIN0, T6.C
- new net N$120: R63.PIN1, T6.E
- new net N$121: C29.PIN0, R64.PIN1, R66.PIN0, T7.B
- new net N$122: C37.PIN1, R67.PIN0, T7.C
- new net N$123: R68.PIN1, T7.E
- new net N$124: C32.PIN1, D6.CATHODE, R69.PIN0
- new net N$125: C25.PIN0, D5.CATHODE, D6.ANODE
- new net N$126: C24.PIN0, R11.PIN1, R12.PIN1, R154.PIN1
- new net N$127: C35.PIN1, D14.CATHODE, R70.PIN0
- new net N$128: C34.PIN0, D13.CATHODE, D14.ANODE
- new net N$129: C27.PIN0, R15.PIN1, R16.PIN1, R72.PIN1
- new net N$130: C38.PIN1, D16.CATHODE, R71.PIN0
- new net N$131: C37.PIN0, D15.CATHODE, D16.ANODE
- new net N$132: J11.PIN1, X6.D-
- new net N$134: C30.PIN0, R66.PIN1, R67.PIN1, R73.PIN1
- net +5V_USB: now also X5.VBUS, X6.VBUS; no longer C3.PIN1, C4.PIN1, DD1.CATHODE, DD2.CATHODE, R1.PIN0, R13.PIN0, SW1.CENTER1, SW1.CENTER2, SW1.POS_A1, SW1.POS_A2, U$1.VCC, X2.VBUS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
- net GND: now also C1.PIN1, C12.PIN0, C13.PIN0, C14.PIN0, C15.PIN0, C16.PIN0, C17.PIN0, C18.-, C19.PIN0, C21.PIN0, C24.PIN1, C27.PIN1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; no longer C1.PIN0, C3.PIN0, C4.PIN0, C6.PIN0, LED1.CATHODE, LED2.CATHODE, LED3.CATHODE, U$1.GND, X1.10, X1.2, X2.GND, X2.PACKAGE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
- net N$1: now also U15OP4.IN-, U15OP4.OUT; no longer C2.PIN1, Q1.2, U$1.PA0(XTAL1)
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Other:
- note removed: "DOWN - SW update"
- note removed: "UP - programming"

Commit message: LCMeter Another changes
Parts:
- added C105, C43: 470uFx16V, __MyCommonLib1:CE10MM
- added C28: 1n0*, __MyCommonLib1:CSMD_0805
- added C31, C40, C42: 0.47uFx16V, __MyCommonLib1:CSMD_0805
- added C41: 1000uFx16V, __MyCommonLib1:CE10MM
- added D104, D17, D18: FR207, __MyCommonLib1:1N4001DO-41_10MM
- added IC12: MC34063, __MyCommonLib1:MC34063(SO-8)
- added R110: 0.62R, __MyCommonLib1:RSMD_1206_BIG_GAP
- added R74: 5K1, __MyCommonLib1:RSMD_1206_BIG_GAP
- added R75: 1K7, __MyCommonLib1:RSMD_1206_BIG_GAP
- added TR1: TRANS, __MyCommonLib1:TRANS_3WINDRING25X10_HOR
Connections:
- new net N$10: D104.CATHODE, IC12.SW_E, TR1.PRI_END
- new net N$133: IC12.DR_C, IC12.I_PEAK, IC12.SW_C, R110.PIN1
- new net N$135: C28.PIN1, IC12.CT
- new net N$136: D18.ANODE, TR1.SEC2_START
- new net N$137: C105.-, C31.PIN1, D104.ANODE
- new net N$138: D17.ANODE, TR1.SEC1_START
- new net N$139: IC12.INV_IN, R74.PIN0, R75.PIN1
- net +5V_USB: now also C40.PIN1, C41.+, IC12.VCC, R110.PIN0
- net GND: now also C105.+, C28.PIN0, C31.PIN0, C40.PIN0, C41.-, C42.PIN0, C43.-, IC12.GND, R75.PIN0, TR1.PRI_START, TR1.SEC1_END, TR1.SEC2_END
- net VCC_ROUGH: now also C42.PIN1, C43.+, D18.CATHODE, R74.PIN1

Commit message: LCMeter schematic is almost complete
Parts:
- added C215, C51, C52, C53: 22uFx16V, __MyCommonLib1:CE6.3MM
- added C44, C46, C49: 0.47uFx16V, __MyCommonLib1:CSMD_0805
- added C45, C47, C48: 470uFx16V, __MyCommonLib1:CE10MM
- added C50: 0.1uF, __MyCommonLib1:CSMD_0805
- added C54, C55: 0.47uF, __MyCommonLib1:CSMD_0805
- added D19, D20, D21, D22, D23, D24, D25, D26, D27, D28: LL4148, __MyCommonLib1:LL4147SOD-80
- added IC15: LM317, __MyCommonLib1:LM317(D2PAK)
- added IC16: 7905, __MyCommonLib1:7905(D2PAK)
- added KEY1: MODE, __MyCommonLib1:KEY(7X4.5)
- added KEY2: RANGE, __MyCommonLib1:KEY(7X4.5)
- added KEY3: RESERVED, __MyCommonLib1:KEY(7X4.5)
- added R76: 5K1, __MyCommonLib1:RSMD_1206_BIG_GAP
- added R77: 1K7, __MyCommonLib1:RSMD_1206_BIG_GAP
- added R78, R79, R80, R81, R82, R83: 4K7, __MyCommonLib1:RSMD_0805
- added X2: MCU_PROGRAMMING, __MyCommonLib1:PIN2X3_2.54MM
Connections:
- removed net ESR_ADC: C33.PIN1, R69.PIN1
- new net ESR_ADC_1X: C33.PIN1, D23.CATHODE, D24.ANODE, IC6.(ADC5)PA5, R69.PIN1
- new net KEY_MODE: IC6.(TOSC1)PC6, R81.PIN1
- new net KEY_RANGE: IC6.(TOSC2)PC7, R82.PIN1
- new net KEY_RESERVED: IC6.PC5, R83.PIN1
- new net MCU_MISO: IC6.(MISO)PB6, X2.6
- new net MCU_MOSI: IC6.(MOSI)PB5, X2.3
- new net MCU_SCK: IC6.(SCK)PB7, X2.4
- new net N$140: C44.PIN1, C45.+, D17.CATHODE, IC15.IN
- new net N$141: C50.PIN1, IC6.AREF
- new net N$142: IC15.ADJ, R76.PIN1, R77.PIN1
- new net N$144: KEY1.1, R80.PIN0, R81.PIN0
- new net N$145: KEY2.1, R79.PIN0, R82.PIN0
- new net N$146: KEY3.1, R78.PIN0, R83.PIN0
- net +5V_FINE: now also C46.PIN1, C47.+, C54.PIN0, C55.PIN0, D20.CATHODE, D22.CATHODE, D24.CATHODE, D26.CATHODE, D27.CATHODE, IC15.OUT, R76.PIN0, R78.PIN1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
- net -5V_FINE: now also C48.-, C49.PIN1, IC16.OUT
- net ESR_ADC_100X: now also D19.CATHODE, D20.ANODE, IC6.(ADC7)PA7
- net ESR_ADC_10X: now also D21.CATHODE, D22.ANODE, IC6.(ADC6)PA6
- net ESR_PWM: now also D27.ANODE, D28.CATHODE, IC6.(OC1B)PD4
- net GND: now also C215.-, C44.PIN0, C45.-, C46.PIN0, C47.-, C48.+, C49.PIN0, C50.PIN0, C51.-, C52.-, C53.+, C54.PIN1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
- net LED_DATA: now also IC6.(T1)PB1
- net LED_LATCH: now also IC6.(T0/XCK)PB0
- net LED_SCK: now also IC6.(AIN0/INT2)PB2
- net L_ADC: now also IC6.(ADC0)PA0
- net L_PWM: now also D25.CATHODE, D26.ANODE, IC6.(OC1A)PD5
- net MCU_RST: now also X2.2
- net N$124: now also C52.+
- net N$127: now also C51.+
- net N$130: now also C215.+
- net N$137: now also IC16.IN
- net N$25: now also C53.-
- net N$7: now also IC6.(TXD)PD1; no longer IC6.(OC1B)PD4
Other:
- moved on the sheet: C1, C105, C2, C20, C28, C3, C31, C33, C36, C39, C40, C41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
