File: LC_METER/schematic/LCMeter.sch (EAGLE design)
At the start: 216 parts, among them IC1 74HC595, IC12 MC34063, IC15 LM317, IC16 7905, IC2 74HC595, IC3 74HC595, IC4 74HC595, IC5 74HC595, IC6 MEGA8535, J10 0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

Commit message: LCMeter start routing
Parts:
- removed C105: 470uFx16V, __MyCommonLib1:CE10MM
- removed C215: 22uFx16V, __MyCommonLib1:CE6.3MM
- removed D104, D17: FR207, __MyCommonLib1:1N4001DO-41_10MM
- removed D19, D21: LL4148, __MyCommonLib1:LL4147SOD-80
- removed IC15: LM317, __MyCommonLib1:LM317(D2PAK)
- removed R110: 0.62R, __MyCommonLib1:RSMD_1206_BIG_GAP
- removed R154: 100R, __MyCommonLib1:RSMD_1206_BIG_GAP
- removed X6: USB_MICRO, __MyCommonLib1:USB_MICROMICRO
- added C56: 0.47uFx16V, __MyCommonLib1:CSMD_1206_BIG_GAP
- added C57: 470uFx16V, __MyCommonLib1:CE10MM
- added D29: FR207, __MyCommonLib1:1N4001DO-41_10MM
- added IC9: LM317, __MyCommonLib1:LM317(D2PAK)
- added R84: 5K1, __MyCommonLib1:RSMD_0805
- added R85: 1K7, __MyCommonLib1:RSMD_0805
- added X3: C_X, con-wago-500:W237-102
- C1, C2: value 0.1uF -> 22pF
- C12, C13: value 22pF -> 0.1uF
- C15, C38: value 0.1uF -> 0.47uF
- C17, C39: value 0.1uF -> 1nF
- C18: value 4.7uF -> 22uFx16V
- C19: value 0.1uF -> 0.47uF; device __MyCommonLib1:CSMD_0805 -> __MyCommonLib1:CSMD_1206_BIG_GAP
- C20: value 1nF -> 0.1uF
- C21: value 22nF* -> 0.1uF
- C22: value 1.0uF -> 0.1uF; device __MyCommonLib1:CSMD_1206_BIG_GAP -> __MyCommonLib1:CSMD_0805
- C27, C30, C33: value 0.1uF -> 22uFx16V; device __MyCommonLib1:CSMD_0805 -> __MyCommonLib1:CE6.3MM
- C28: value 1n0* -> 0.1uF
- C31, C42: value 0.47uFx16V -> 0.1uF
- C4: value 1nF -> 4.7uF; device __MyCommonLib1:CSMD_0805 -> __MyCommonLib1:CE6.3MM
- C40: value 0.47uFx16V -> 1.0uF; device __MyCommonLib1:CSMD_0805 -> __MyCommonLib1:CSMD_1206_BIG_GAP
- C41: value 1000uFx16V -> 0.1uF; device __MyCommonLib1:CE10MM -> __MyCommonLib1:CSMD_0805
- C43: value 470uFx16V -> 0.1uF; device __MyCommonLib1:CE10MM -> __MyCommonLib1:CSMD_0805
- C44: value 0.47uFx16V -> 22nF*
- C45, C47: value 470uFx16V -> 0.47uFx16V; device __MyCommonLib1:CE10MM -> __MyCommonLib1:CSMD_0805
- C46: value 0.47uFx16V -> 470uFx16V; device __MyCommonLib1:CSMD_0805 -> __MyCommonLib1:CE10MM
- C48: value 470uFx16V -> 47uFx16V; device __MyCommonLib1:CE10MM -> __MyCommonLib1:CE6.3MM
- C49: device __MyCommonLib1:CSMD_0805 -> __MyCommonLib1:CSMD_1206
- C5: value 0.47uF -> 0.1uF; device __MyCommonLib1:CSMD_1206_BIG_GAP -> __MyCommonLib1:CSMD_0805
- C50: value 0.1uF -> 470uFx16V; device __MyCommonLib1:CSMD_0805 -> __MyCommonLib1:CE10MM
- C51: value 22uFx16V -> 0.47uFx16V; device __MyCommonLib1:CE6.3MM -> __MyCommonLib1:CSMD_0805
- C52: value 22uFx16V -> 47uFx16V; device __MyCommonLib1:CE6.3MM -> __MyCommonLib1:CE10MM
- C53: value 22uFx16V -> 1000uFx16V; device __MyCommonLib1:CE6.3MM -> __MyCommonLib1:CE10MM
- C54: value 0.47uF -> 0.47uFx16V; device __MyCommonLib1:CSMD_0805 -> __MyCommonLib1:CSMD_1206
- C55: value 0.47uF -> 1n0*
- D18: value FR207 -> LL4148; device __MyCommonLib1:1N4001DO-41_10MM -> __MyCommonLib1:LL4147SOD-80
- D27, D28: value LL4148 -> FR207; device __MyCommonLib1:LL4147SOD-80 -> __MyCommonLib1:1N4001DO-41_10MM
- IC1: value 74HC595 -> MEGA8535; device __MyCommonLib1:74HC595(SOIC16) -> atmel:MEGA8535-A
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Connections:
- removed net N$98 (its old number): IC1.SER_OUT, IC2.SER_IN
- new net N$99: IC5.SER_OUT, IC6.SER_IN
- net +5V_FINE: now also C15.PIN0, C21.PIN1, C38.PIN0, C4.+, C5.PIN1, C51.PIN1, C52.+, C6.PIN1, C7.PIN1, C8.PIN1, C9.PIN1, D11.CATHODE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; no longer C14.PIN1, C15.PIN1, C16.PIN1, C17.PIN1, C18.+, C19.PIN1, C2.PIN1, C46.PIN1, C47.+, C54.PIN0, C55.PIN0, D20.CATHODE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
- net +5V_USB: now also C53.+, C54.PIN1, R83.PIN0, X4.VBUS; no longer C40.PIN1, C41.+, R110.PIN0, X6.VBUS
- net -5V_FINE: now also C25.PIN0, C47.PIN1; no longer C1.PIN0, C49.PIN1
- net ESR_ADC_100X: now also C32.PIN1, D13.ANODE, IC1.(ADC7)PA7, R63.PIN1; no longer C39.PIN1, D19.CATHODE, D20.ANODE, IC6.(ADC7)PA7, R71.PIN1
- net ESR_ADC_10X: now also C29.PIN1, D12.ANODE, IC1.(ADC6)PA6, R62.PIN1; no longer C36.PIN1, D21.CATHODE, D22.ANODE, IC6.(ADC6)PA6, R70.PIN1
- net ESR_ADC_1X: now also C26.PIN1, D11.ANODE, IC1.(ADC5)PA5, R61.PIN1; no longer C33.PIN1, D23.CATHODE, D24.ANODE, IC6.(ADC5)PA5, R69.PIN1
- net ESR_PWM: now also C39.PIN1, D23.ANODE, D24.CATHODE, IC1.(OC1B)PD4, R74.PIN0; no longer C20.PIN1, D27.ANODE, D28.CATHODE, IC6.(OC1B)PD4, R3.PIN0
- net GND: now also C1.PIN0, C15.PIN1, C18.+, C20.PIN1, C25.PIN1, C26.PIN0, C27.-, C29.PIN0, C3.PIN0, C30.-, C33.-, C34.PIN0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; no longer C1.PIN1, C105.+, C15.PIN0, C16.PIN0, C17.PIN0, C18.-, C215.-, C24.PIN1, C27.PIN1, C3.PIN1, C30.PIN1, C33.PIN0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
- net KEY_MODE: now also IC1.(TOSC1)PC6, R5.PIN1; no longer IC6.(TOSC1)PC6, R81.PIN1
- net KEY_RANGE: now also IC1.(TOSC2)PC7, R6.PIN1; no longer IC6.(TOSC2)PC7, R82.PIN1
- net KEY_RESERVED: now also IC1.PC5, R7.PIN1; no longer IC6.PC5, R83.PIN1
- net LED_DATA: now also IC1.(T1)PB1, R17.PIN0; no longer IC6.(T1)PB1, R59.PIN0
- net LED_DATA': now also D3.ANODE, D6.CATHODE, IC2.SER_IN, R17.PIN1; no longer D12.ANODE, D9.CATHODE, IC1.SER_IN, R59.PIN1
- net LED_LATCH: now also IC1.(T0/XCK)PB0, R21.PIN0; no longer IC6.(T0/XCK)PB0, R61.PIN0
- net LED_LATCH': now also D1.ANODE, D4.CATHODE, R21.PIN1; no longer D10.ANODE, D7.CATHODE, R61.PIN1
- net LED_SCK: now also IC1.(AIN0/INT2)PB2, R19.PIN0; no longer IC6.(AIN0/INT2)PB2, R60.PIN0
- net LED_SCK': now also D2.ANODE, D5.CATHODE, R19.PIN1; no longer D11.ANODE, D8.CATHODE, R60.PIN1
- net L_ADC: now also C20.PIN0, D10.CATHODE, IC1.(ADC0)PA0, R59.PIN1; no longer C3.PIN0, D2.CATHODE, IC6.(ADC0)PA0, R2.PIN1
- net L_PWM: now also C17.PIN1, D7.ANODE, D9.CATHODE, IC1.(OC1A)PD5, R55.PIN0; no longer C4.PIN1, D25.CATHODE, D26.ANODE, IC6.(OC1A)PD5, R6.PIN0
- net MCU_MISO: now also IC1.(MISO)PB6, X1.6; no longer IC6.(MISO)PB6, X2.6
- net MCU_MOSI: now also IC1.(MOSI)PB5, X1.3; no longer IC6.(MOSI)PB5, X2.3
- net MCU_RST: now also IC1.RESET, R1.PIN1, X1.2; no longer IC6.RESET, R62.PIN1, X2.2
- net MCU_SCK: now also IC1.(SCK)PB7, X1.4; no longer IC6.(SCK)PB7, X2.4
- net N$10: now also D27.CATHODE; no longer D104.CATHODE
- net N$100: now also IC2.SER_CLK; no longer IC1.SER_CLK
- net N$101: now also IC2.LATCH; no longer IC1.LATCH
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
Commit message: LCMeter routing
Parts:
- removed D4, D5, D6: LL4148, __MyCommonLib1:LL4147SOD-80
- R64, R65, R66: device __MyCommonLib1:RSMD_1206_BIG_GAP -> __MyCommonLib1:RSMD_0805
Connections:
- net ESR_ADC_100X: now also IC1.(ADC5)PA5; no longer IC1.(ADC7)PA7
- net ESR_ADC_10X: now also IC1.(ADC4)PA4; no longer IC1.(ADC6)PA6
- net ESR_ADC_1X: now also IC1.(ADC3)PA3; no longer IC1.(ADC5)PA5
- net GND: no longer D4.ANODE, D5.ANODE, D6.ANODE
- net KEY_MODE: now also IC1.PC4; no longer IC1.(TOSC1)PC6
- net KEY_RANGE: now also IC1.PC5; no longer IC1.(TOSC2)PC7
- net KEY_RESERVED: now also IC1.(TOSC1)PC6; no longer IC1.PC5
- net LED_DATA: now also IC1.PC2; no longer IC1.(T1)PB1
- net LED_DATA': no longer D6.CATHODE
- net LED_LATCH: now also IC1.PC1(SDA); no longer IC1.(T0/XCK)PB0
- net LED_LATCH': no longer D4.CATHODE
- net LED_SCK: now also IC1.PC3; no longer IC1.(AIN0/INT2)PB2
- net LED_SCK': no longer D5.CATHODE
Changed lines of the file:
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@@
 <setting verticaltext="up"/>
 </settings>
-<grid distance="0.1" unitdist="inch" unit="inch" style="lines" multiple="1" display="yes" altdistance="0.01" altunitdist="inch" altunit="inch"/>
+<grid distance="0.05" unitdist="inch" unit="inch" style="lines" multiple="2" display="yes" altdistance="0.01" altunitdist="inch" altunit="inch"/>
 <layers>
 <layer number="1" name="Top" color="4" fill="1" visible="yes" active="no"/>
@@
 <part name="R19" library="__MyCommonLib1" deviceset="R" device="SMD_0805" value="300R"/>
 <part name="R21" library="__MyCommonLib1" deviceset="R" device="SMD_0805" value="300R"/>
-<part name="D4" library="__MyCommonLib1" deviceset="LL4147" device="SOD-80" value="LL4148"/>
-<part name="D5" library="__MyCommonLib1" deviceset="LL4147" device="SOD-80" value="LL4148"/>
-<part name="D6" library="__MyCommonLib1" deviceset="LL4147" device="SOD-80" value="LL4148"/>
-<part name="GND33" library="supply1" deviceset="GND" device=""/>
-<part name="GND34" library="supply1" deviceset="GND" device=""/>
-<part name="GND35" library="supply1" deviceset="GND" device=""/>
 <part name="D1" library="__MyCommonLib1" deviceset="LL4147" device="SOD-80" value="LL4148"/>
 <part name="D2" library="__MyCommonLib1" deviceset="LL4147" device="SOD-80" value="LL4148"/>
@@
 <part name="GND63" library="supply1" deviceset="GND" device=""/>
 <part name="GND64" library="supply1" deviceset="GND" device=""/>
-<part name="R64" library="__MyCommonLib1" deviceset="R" device="SMD_1206_BIG_GAP" value="100R"/>
-<part name="R65" library="__MyCommonLib1" deviceset="R" device="SMD_1206_BIG_GAP" value="100R"/>
-<part name="R66" library="__MyCommonLib1" deviceset="R" device="SMD_1206_BIG_GAP" value="100R"/>
+<part name="R64" library="__MyCommonLib1" deviceset="R" device="SMD_0805" value="100R"/>
+<part name="R65" library="__MyCommonLib1" deviceset="R" device="SMD_0805" value="100R"/>
+<part name="R66" library="__MyCommonLib1" deviceset="R" device="SMD_0805" value="100R"/>
 <part name="FRAME4" library="frames" deviceset="A4L-LOC" device="" value="PWR_SUPPLY"/>
 <part name="ZD1" library="__MyCommonLib1" deviceset="ZENNER" device="(SOD_80)" value="3V6"/>
@@
 <net name="ESR_ADC_100X" class="0">
 <segment>
-<pinref part="IC1" gate="G$1" pin="(ADC7)PA7"/>
-<wire x1="88.9" y1="162.56" x2="104.14" y2="162.56" width="0.1524" layer="91"/>
-<label x="104.14" y="163.83" size="1.27" layer="95" font="vector" ratio="20" rot="R180"/>
-</segment>
-</net>
-<net name="ESR_ADC_10X" class="0">
-<segment>
-<pinref part="IC1" gate="G$1" pin="(ADC6)PA6"/>
-<wire x1="88.9" y1="160.02" x2="104.14" y2="160.02" width="0.1524" layer="91"/>
-<label x="104.14" y="161.29" size="1.27" layer="95" font="vector" ratio="20" rot="R180"/>
-</segment>
-</net>
-<net name="ESR_ADC_1X" class="0">
-<segment>
 <pinref part="IC1" gate="G$1" pin="(ADC5)PA5"/>
 <wire x1="88.9" y1="157.48" x2="104.14" y2="157.48" width="0.1524" layer="91"/>
@@
 </segment>
 </net>
+<net name="ESR_ADC_10X" class="0">
+<segment>
+<pinref part="IC1" gate="G$1" pin="(ADC4)PA4"/>
+<wire x1="88.9" y1="154.94" x2="104.14" y2="154.94" width="0.1524" layer="91"/>
+<label x="104.14" y="156.21" size="1.27" layer="95" font="vector" ratio="20" rot="R180"/>
+</segment>
+</net>
+<net name="ESR_ADC_1X" class="0">
+<segment>
+<pinref part="IC1" gate="G$1" pin="(ADC3)PA3"/>
+<wire x1="88.9" y1="152.4" x2="104.14" y2="152.4" width="0.1524" layer="91"/>
+<label x="104.14" y="153.67" size="1.27" layer="95" font="vector" ratio="20" rot="R180"/>
+</segment>
+</net>
 <net name="N$7" class="0">
 <segment>
@@
 <net name="LED_SCK" class="0">
 <segment>
-<pinref part="IC1" gate="G$1" pin="(AIN0/INT2)PB2"/>
-<wire x1="88.9" y1="127" x2="101.6" y2="127" width="0.1524" layer="91"/>
-<label x="101.6" y="128.905" size="1.27" layer="95" font="vector" ratio="20" rot="R180"/>
+<pinref part="IC1" gate="G$1" pin="PC3"/>
+<wire x1="88.9" y1="106.68" x2="104.14" y2="106.68" width="0.1524" layer="91"/>
+<label x="104.14" y="107.95" size="1.27" layer="95" font="vector" ratio="20" rot="R180"/>
 </segment>
 </net>
 <net name="LED_DATA" class="0">
 <segment>
-<pinref part="IC1" gate="G$1" pin="(T1)PB1"/>
-<wire x1="88.9" y1="124.46" x2="101.6" y2="124.46" width="0.1524" layer="91"/>
-<label x="101.6" y="126.365" size="1.27" layer="95" font="vector" ratio="20" rot="R180"/>
+<pinref part="IC1" gate="G$1" pin="PC2"/>
+<wire x1="88.9" y1="104.14" x2="104.14" y2="104.14" width="0.1524" layer="91"/>
+<label x="104.14" y="105.41" size="1.27" layer="95" font="vector" ratio="20" rot="R180"/>
 </segment>
 </net>
 <net name="LED_LATCH" class="0">
 <segment>
-<pinref part="IC1" gate="G$1" pin="(T0/XCK)PB0"/>
-<wire x1="88.9" y1="121.92" x2="101.6" y2="121.92" width="0.1524" layer="91"/>
-<label x="101.6" y="123.825" size="1.27" layer="95" font="vector" ratio="20" rot="R180"/>
+<pinref part="IC1" gate="G$1" pin="PC1(SDA)"/>
+<wire x1="88.9" y1="101.6" x2="104.14" y2="101.6" width="0.1524" layer="91"/>
+<label x="104.14" y="102.87" size="1.27" layer="95" font="vector" ratio="20" rot="R180"/>
 </segment>
 </net>
@@
 </segment>
 <segment>
-<pinref part="IC1" gate="G$1" pin="(TOSC1)PC6"/>
-<wire x1="88.9" y1="114.3" x2="104.14" y2="114.3" width="0.1524" layer="91"/>
-<label x="104.14" y="116.205" size="1.27" layer="95" font="vector" ratio="20" rot="R180"/>
+<pinref part="IC1" gate="G$1" pin="PC4"/>
+<wire x1="88.9" y1="109.22" x2="104.14" y2="109.22" width="0.1524" layer="91"/>
+<label x="104.14" y="110.49" size="1.27" layer="95" font="vector" ratio="20" rot="R180"/>
 </segment>
 </net>
@@
 </segment>
 <segment>
-<pinref part="IC1" gate="G$1" pin="(TOSC2)PC7"/>
-<wire x1="88.9" y1="116.84" x2="104.14" y2="116.84" width="0.1524" layer="91"/>
-<label x="104.14" y="118.745" size="1.27" layer="95" font="vector" ratio="20" rot="R180"/>
+<pinref part="IC1" gate="G$1" pin="PC5"/>
+<wire x1="88.9" y1="111.76" x2="104.14" y2="111.76" width="0.1524" layer="91"/>
+<label x="104.14" y="113.03" size="1.27" layer="95" font="vector" ratio="20" rot="R180"/>
 </segment>
 </net>
@@
 </segment>
 <segment>
-<pinref part="IC1" gate="G$1" pin="PC5"/>
-<wire x1="88.9" y1="111.76" x2="104.14" y2="111.76" width="0.1524" layer="91"/>
-<label x="104.14" y="113.665" size="1.27" layer="95" font="vector" ratio="20" rot="R180"/>
+<pinref part="IC1" gate="G$1" pin="(TOSC1)PC6"/>
+<wire x1="88.9" y1="114.3" x2="104.14" y2="114.3" width="0.1524" layer="91"/>
+<label x="104.14" y="115.57" size="1.27" layer="95" font="vector" ratio="20" rot="R180"/>
 </segment>
 </net>
@@
 <attribute name="VALUE" x="22.86" y="139.7" size="1.27" layer="96" font="vector" ratio="20" rot="MR180"/>
 </instance>
-<instance part="D4" gate="D1" x="30.48" y="142.24" smashed="yes">
-<attribute name="NAME" x="29.21" y="128.27" size="1.27" layer="95" font="vector" ratio="20"/>
-<attribute name="VALUE" x="34.29" y="129.54" size="1.27" layer="96" font="vector" ratio="20"/>
-</instance>
-<instance part="D5" gate="D1" x="35.56" y="142.24" smashed="yes">
-<attribute name="NAME" x="29.21" y="125.73" size="1.27" layer="95" font="vector" ratio="20"/>
-<attribute name="VALUE" x="34.29" y="127" size="1.27" layer="96" font="vector" ratio="20"/>
-</instance>
-<instance part="D6" gate="D1" x="40.64" y="142.24" smashed="yes">
-<attribute name="NAME" x="29.21" y="123.19" size="1.27" layer="95" font="vector" ratio="20"/>
-<attribute name="VALUE" x="34.29" y="124.46" size="1.27" layer="96" font="vector" ratio="20"/>
-</instance>
-<instance part="GND33" gate="1" x="30.48" y="134.62" smashed="yes"/>
-<instance part="GND34" gate="1" x="35.56" y="134.62" smashed="yes"/>
-<instance part="GND35" gate="1" x="40.64" y="134.62" smashed="yes"/>
 <instance part="D1" gate="D1" x="30.48" y="157.48" smashed="yes">
 <attribute name="NAME" x="29.21" y="166.37" size="1.27" layer="95" font="vector" ratio="20" rot="R180"/>
@@
 <pinref part="C14" gate="C$1" pin="PIN0"/>
 <wire x1="231.14" y1="154.94" x2="231.14" y2="152.4" width="0.1524" layer="91"/>
-</segment>
-<segment>
-<pinref part="GND33" gate="1" pin="GND"/>
-<pinref part="D4" gate="D1" pin="ANODE"/>
-<wire x1="30.48" y1="137.16" x2="30.48" y2="139.7" width="0.1524" layer="91"/>
-</segment>
-<segment>
-<pinref part="D5" gate="D1" pin="ANODE"/>
-<pinref part="GND34" gate="1" pin="GND"/>
-<wire x1="35.56" y1="139.7" x2="35.56" y2="137.16" width="0.1524" layer="91"/>
-</segment>
-<segment>
-<pinref part="D6" gate="D1" pin="ANODE"/>
-<pinref part="GND35" gate="1" pin="GND"/>
-<wire x1="40.64" y1="139.7" x2="40.64" y2="137.16" width="0.1524" layer="91"/>
 </segment>
 </net>
@@
 <junction x="45.72" y="99.06"/>
 <pinref part="R19" gate="R$1" pin="PIN1"/>
-<pinref part="D5" gate="D1" pin="CATHODE"/>
-<wire x1="35.56" y1="144.78" x2="35.56" y2="149.86" width="0.1524" layer="91"/>
 <junction x="35.56" y="149.86"/>
 <pinref part="D2" gate="D1" pin="ANODE"/>
@@
 <wire x1="43.18" y1="152.4" x2="40.64" y2="152.4" width="0.1524" layer="91"/>
 <pinref part="R17" gate="R$1" pin="PIN1"/>
-<pinref part="D6" gate="D1" pin="CATHODE"/>
 <wire x1="40.64" y1="152.4" x2="27.94" y2="152.4" width="0.1524" layer="91"/>
-<wire x1="40.64" y1="144.78" x2="40.64" y2="152.4" width="0.1524" layer="91"/>
 <junction x="40.64" y="152.4"/>
 <pinref part="D3" gate="D1" pin="ANODE"/>
@@
 <junction x="48.26" y="91.44"/>
 <pinref part="R21" gate="R$1" pin="PIN1"/>
-<pinref part="D4" gate="D1" pin="CATHODE"/>
-<wire x1="30.48" y1="144.78" x2="30.48" y2="147.32" width="0.1524" layer="91"/>
 <junction x="30.48" y="147.32"/>
 <pinref part="D1" gate="D1" pin="ANODE"/>

Commit message: LCMeter start routing2
Parts:
- removed J1, J2, J3, J5, J7: 0, __MyCommonLib1:RSMD_1206_BIG_GAP
- added R86, R87, R88: 1K0, __MyCommonLib1:RSMD_0805
- J10, J4, J6, J8, J9: device __MyCommonLib1:RSMD_1206_BIG_GAP -> __MyCommonLib1:RSMD_0805
Connections:
- removed net N$100: IC2.SER_CLK, J1.PIN1
- removed net N$101: IC2.LATCH, J2.PIN1
- removed net N$102: IC3.SER_CLK, J3.PIN1
- removed net N$105: IC5.SER_CLK, J7.PIN1
- removed net N$106: IC4.SER_CLK, J5.PIN1
- net GND: now also R86.PIN0, R87.PIN0, R88.PIN0
- net LED_DATA: now also IC1.PC1(SDA); no longer IC1.PC2
- net LED_LATCH: now also IC1.PC2; no longer IC1.PC1(SDA)
- net LED_LATCH': now also IC2.LATCH; no longer J2.PIN0
- net LED_SCK': now also IC2.SER_CLK, IC3.SER_CLK, IC4.SER_CLK, IC5.SER_CLK; no longer J1.PIN0, J3.PIN0, J5.PIN0, J7.PIN0
- net N$124: now also R86.PIN1
- net N$127: now also R87.PIN1
- net N$130: now also R88.PIN1
Other:
- moved on the sheet: C26, C29, C32, D11, D12, D13, R61, R62, R63
